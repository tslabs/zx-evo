-cZ80
//-Hff
//-Fraw-binary
-Fintel-extended
-Z(CODE)RCODE,CODE,CDATA0,CONST,CSTR,CCSTR,FONT=6000
-Z(DATA)DATA0,IDATA0,UDATA0,ECSTR,TEMP=6000
-Z(DATA)CSTACK=5FFF
-xehmisn
