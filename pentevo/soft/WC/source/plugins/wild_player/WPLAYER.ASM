;Wild Player plugin
;(C) KOSHI/MGN 2026
;-------------------------------------------;
;source for wild commander ASM compiler v1.0;
;-------------------------------------------;
HEADER  EQU #0000
MAINCOD EQU #0200
COD1PG  EQU 0; Main code page
COD2PG  EQU 3; Resident code page
PL1PG   EQU 1; Players1 page
PL2PG   EQU 2; Players2 page

COD1LN  EQU 16; Main cod length
PL1LN   EQU 32; Players1 length
PL2LN   EQU 9;  Players2 length
COD2LN  EQU ENDCOD2-STARTCOD2; Resident code length

PLAYER1 EQU MAINCOD+COD1LN*512
PLAYER2 EQU PLAYER1+PL1LN*512
COD2    EQU PLAYER2+PL2LN*512

NZ0CHAR EQU 9+11;     Noize Low
NZHCHAR EQU NZ0CHAR+5;Noize Hi
;-------
RESIDENT_JP   EQU #6020; Plugin System
RESIDENT_CALL EQU #6028; Plugin System
;-------
Frames  EQU 49;        Frames per sec
TimeOut EQU Frames*10; 10 Secs wait MAX
F10flg  EQU 3

        ORG HEADER
;-------
WLD     EQU #6006; Plugin System Call Point
TMN     EQU #6009; Timer
HEI     EQU #600E; Height (25,30,36)
FUX     EQU #6026

PLHDRS  EQU 5; Play List Headers
;-------
        DS 16
        DB "WildCommanderMDL";    Header
        DB #11;                  Version
        DB 0
        DB 4; Pages to store
        DB 0; Page to #8000 at Start

        DB COD1PG,COD1LN;      MAIN code
        DB PL1PG,PL1LN;       PLAYERS1
        DB PL2PG,PL2LN;       PLAYERS2
        DB COD2PG,COD2LN/512+1;RESIDENT
.2      DB 0,0

        DS 16

        DB "C  ";0
        DB "M  "
        DB "MUZ"
        DB "$M "
        DB "$P "

        DB "ASC";5
        DB "SQT"
        DB "STC"
        DB "FLS"
        DB "STP"
        DB "FTC"
        DB "PSC"

        DB "PT1";12
        DB "PT2"
        DB "PT3"
        DB "GTR"
        DB "TFC"
        DB "VTX"
        DB "VT "
        DB "FXM"
        DB "SAA"
        DB "PSM";21
        DB "ETC";22

        DB "P_M";23
        DB "P_C"
        DB "P_S"
        DB "P_A"
        DB "P_P"
        DB "P_F"
        DB "TFD";29

        DB "AYL";30
        DB "M3U";31
        DB 0;    end token

        DW #0000,#000F;                        Max File Size
        DB "Wild Player Plug-in v1.84       "; Plugin Name
        DB 5;                                  Type (SHIFT+F3;F10 menu;by EXT)
        DS 6
        DB "Play by Wild Player     ";         Green menu
        DS 32
;WC.INI options:
PAR1    DB PAR2-PAR1;Structure size
        DB 1;Default option
        DB "repeat"
        DB 2;Options count
        DB "all",0
        DB "one",0
PAR2    DB PAR3-PAR2
        DB 3;Default option
        DB "mode"
        DB 3;Options count
        DB "forward",0
        DB "backward",0
        DB "shuffle",0
PAR3    DB PAR3END-PAR3
        DB 1;Default option
        DB "stop"
        DB 2;Options count
        DB "no",0
        DB "yes",0
PAR3END NOP;END TOKEN
;---------------------------------------
        ORG #8000,MAINCOD
;-------
;Text screen modes:
HEIMIN  EQU 25
HEIMID  EQU 30
HEIMAX  EQU 36

;Main Window
MDXzero EQU 19;       X without PlayList (txt mode 80)
MDXZ36  EQU 24;       X without PL (txt mode 90)
MDX     EQU 4;        X mode 80
MDX36   EQU 9;        X mode 90
MDY     EQU 5;        Y mode 30
MDY25   EQU 3;        Y mode 25
MDY36   EQU 8;        Y mode 36
MDW     EQU 42;       width
MDH     EQU 15;       height

;Analyzer Window
ANX     EQU MDX
ANX36   EQU MDX36
ANY     EQU MDY+MDH-1
ANY25   EQU MDY25+MDH-1
ANY36   EQU MDY36+MDH-1
ANW     EQU MDW
ANH     EQU 4

;PlayList Window
PLX     EQU MDX+MDW
PLX36   EQU MDX36+MDW
PLY     EQU MDY
PLY25   EQU MDY25
PLY36   EQU MDY36
PLW     EQU 30
PLH     EQU MDH+ANH-1

;Help Window
HLPX    EQU 255
HLPX25  EQU 255
HLPX36  EQU 255
HLPY    EQU ANY+ANH+1
HLPY25  EQU ANY25+ANH
HLPY36  EQU ANY36+ANH+1
HLPW    EQU 62
HLPH    EQU 6
HLPC    EQU %01001111

;Warning Window
ERRW    EQU 40
ERRH    EQU 2+2
ERRC    EQU %10101111

;Loading Window
LOADW   EQU 40
LOADH   EQU 1+2
LOADC   EQU %01101111

CURclrP EQU MDC-1
CURclr  EQU %01011000
CURmsk  EQU %00000111
MDC     EQU %01111111
;-------
INSTM   EQU #C000
PLAYM   EQU #C005
STOPM   EQU #C008

TFDPLAY EQU #C003;TFD PLAY point
TFDCUR  EQU #C009;TFD PLAY offset (PLAYER)
EOM     EQU #C00D;TFD EndOfMusic flag (PLAYER)
TFDFLG  EQU 3
TFDPATCH  EQU INSTM+#32;OUT (#FE) -> NOP:NOP
TFDPATCH2 EQU INSTM+#39;OUT (#FE) -> NOP:NOP
;-------
PT3PL   EQU #0BE1
PT2PL   EQU #0A0C
FMPL    EQU #0743
VTPL    EQU #086E
;-------
SECBU   EQU #9E00
LOBU    EQU #A000
;---------------------------------------
WP333   LD (DAIX),IX,E,1
        LD (SSTAT),A:CP F10flg:CALL Z,LOADtest
        EXA:LD (EXTNUM),A;    file EXT number (0-31)
        LD (DADE),HL;         file size [DE,HL]
        LD (FILEINF+1),BC;    file name string
        XOR A:LD (WINDZ+1),A; window printed flag 
        LD A,E,(ESTAT),A;     exit state flag (1 - unknown file)

        CALL INITZ;        inits (RNDseed, loadINIoptions)
        LD A,(EXTNUM):CP 30:JR C,NOPL; 30=AYL, 31=M3U

;AYL/M3U:
        XOR A
        LD (ESTAT),A
        CALL EXGENPL
        CALL GEDPL
        CALL ONLY1TRACK:JP Z,ENTRnPL;If 1 track in PL -> play it in standard mode

;play list mode:
PLSTART CALL NEED
        LD HL,(PLGE),BC,0-#C000:ADD HL,BC
.2      SRL H:RR L
        LD (PLcount),HL
        JP ENTR;load firs music in PL, then going to main cycle
;-------
YEMR    ;Marked Files -> Play List
        CALL MGENPL
        LD HL,(FILEINF+1),(HL),0
        JR PLSTART

;not AYL/m3u:
NOPL    LD HL,0:CALL TMRKDFL:JR NZ,YEMR
;no marked files:
NOMR    ;CALL UGENPL
        LD A,1,(PLMD),A; Play List mode off
;-------
NEW     CALL NP6,NP06
        CALL GEDPL
        LD A,(SSTAT):CP F10flg:JR NZ,NORMIS:CALL LOADtst:JR SIMRON
NORMIS  LD B,16+32,HL,LOBU:CALL LOAD512
        LD B,32:CALL LOAD512

SIMRON  LD A,(DETKA):OR A:CALL NZ,TFMDET

        CALL ZAPUMZ
        CALL NEED

        LD A,(MUZPL):OR A:JR NZ,MAIN
        CALL LMD,Z,WARNING:JR NZ,EXI4
        LD A,(Mloop):OR A:JP Z,NXTMZ;if music not started go to next (ALL)
        LD A,(Mstop):OR A:JP Z,NXTMZ;ONE+PLAY
;ONE+STOP

MAIN    EI:HALT:CALL ATIT

        CALL PMACH:JP NZ,NXTMZ
        CALL CLOCK:LD HL,ANALYZEanpr,A,(TSMZ),BC,(FMMZ):CALL COD2RES
        CALL LMD,Z,PLSHOW

        LD IX,PLWND
        CALL LMD:JR NZ,WOPL
        CALL CURSOR,PBNOW
        CALL UPPP,NZ,CRUP
        CALL DWWW,NZ,CRDN

WOPL    CALL F1KE,NZ,HLPSHOW
        CALL F2KE,NZ,MODLOOP
        CALL F3KE,NZ,MODSTEP
        CALL F4KE,NZ,MODSTOP

        CALL ENKE:JP NZ,ENTR
        CALL SPKE:JR NZ,NXTMZ

        LD A,1:CALL KBSCN
        CP "m":CALL Z,PAUSE_MUSIC

        CALL ESC:JR Z,MAIN

EXI4    XOR A:LD (ESTAT),A
EXI3    EI:HALT
        CALL DEFNT
        LD HL,HLPWNDrresb:CALL HMD,NZ,COD2RES
        LD IX,PLWND:CALL LMD,Z,RRESB
        LD HL,ANWNDrresb:CALL COD2RES

        CALL AYOFF
        LD IX,MNWND:CALL RRESB

        LD A,(ESTAT):CP 2:RET C
        CALL LMD:LD A,2:RET NZ
        XOR A
        RET
;-------
PAUSE_MUSIC LD A,1,HL,PAUS:XOR (HL):LD (HL),A:JP AYOFF
;-------
LMD     LD A,(PLMD):OR A:RET
HMD     LD A,(HPMD):OR A:RET
;-------
NXTMZ   LD A,(Mstop),C,A
        LD A,(Mloop):DEC A:JR NZ,ALLmd:DEC C:JP Z,STOP,ENTR;ONE

ALLmd   CALL LMD:JR NZ,ENTR
        LD IX,PLWND
        LD A,(Mstep)
        DEC A:JR Z,BCKWARD;BCKWARD
        DEC A:JR Z,SHUFFLE;SHUFFLE
        JR FORWARD
SHUFFLE LD BC,(PLcount):DEC BC:LD A,B:OR C:INC BC:JR Z,ONEpi
        LD HL,RND_GENres:CALL COD2RES
        LD HL,BC,DE,(PLAYcur):OR A:SBC HL,DE:JR Z,SHUFFLE
ONEpi   LD HL,BC:CALL PLGO
        JR ENTR
BCKWARD CALL PlayCRUP:JR WARD
FORWARD CALL PlayCRDN
WARD    JR NC,ENTR
        LD A,(Mstop):DEC A:JR Z,STOP
;Forward repeat ALL
        CALL PLINT
        LD A,(Mstep):OR A:JR Z,ORDER1;FORWARD
        LD HL,(PLcount):DEC HL:CALL PLGO
ORDER1  LD A,(MUZPL):OR A:JP Z,MAIN
        JR ENTR

ENTRnPL LD A,1,(PLMD),A:CALL NEED:JR ENTRnpl;PL with 1 track -> no PL
ENTR    CALL AYOFF
        CALL LMD:JP NZ,EXI3;Next File if not in PL mode
ENTRnpl CALL GWZ:JP C,EXI3
        LD (PLAYcur),DE,(IX+24),1;Playing cursor

        LD DE,SECBU
        PUSH DE:XOR A:LD (DE),A:INC DE
        LD BC,#FF0E:CALL Ldr
        XOR A:LD (DE),A
       LD HL,LOADINGprwow:CALL COD2RES
        POP HL
        CALL FENTRY:LD (DADE),HL
       PUSH AF:LD HL,LOADINGrresb:CALL COD2RES
       POP AF:JP Z,EXI3
;LD A,D:OR E:JR NZ,EXI3
;LD (DADE),HL
        CALL GFILE
        JP NEW

STOP    LD HL,#0100,(MUZPL),HL:CALL AYOFF:JP MAIN
;-------
CRUP    LD IX,PLWND
        LD A,(IX+12):CP 1:JR Z,SRLUP:DEC (IX+12)
        JR RFRH
SRLUP   LD L,(IX+22),H,(IX+23)
        LD A,L:OR H:JR Z,EDGE
        DEC HL
GLOB    LD (IX+22),L,(IX+23),H
        JR RFRH

CRDN    LD IX,PLWND
        LD A,(IX+12):CP (IX+13):JR NC,SRLDN:INC (IX+12)
RFRH    LD (IX+24),1
        XOR A
        RET
SRLDN   INC (IX+12):CALL GWZ
        DEC (IX+12):RET C

        LD L,(IX+22),H,(IX+23):INC HL
        JR GLOB
EDGE    SCF
        RET
;-------
PlayCRUP CALL PlayEcur:JR Z,CRUP

         EX DE,HL:DEC HL
         CALL PLGO:JR NC,EDGE
         XOR A
         RET
PlayCRDN CALL PlayEcur:JR Z,CRDN

         EX DE,HL:INC HL
         CALL PLGO:JR NC,EDGE
         XOR A
         RET

PlayEcur LD (IX+24),1
         LD DE,(PLAYcur)
         LD L,(IX+22)
         LD H,(IX+23)
         LD B,0
         LD C,(IX+12):DEC C
         ADD HL,BC
         OR A:SBC HL,DE
         RET
;---------------------------------------
MODLOOP LD HL,Mloop,DE,MLOOP:JP TTT
MODSTEP LD HL,Mstep,DE,MSTEP:JP TTT
MODSTOP LD HL,Mstop,DE,MSTOP:JP TTT
;-------
PBNOW   LD DE,(PLcount),B,0:CALL PB_PL
        LD L,(IX+22)
        LD H,(IX+23),B,1:JP PB_PL
;---------------------------------------
;Reset play modes, init , one time inits
INITZ   LD A,0:OR A:CALL Z,FIRST_S

        XOR A
        LD (PLMD),A
        LD (HPMD),A
        LD (ANFNT+1),A

        LD C,0;just init (update field)
        LD HL,Mloop,DE,MLOOP:CALL T_T
        LD HL,Mstep,DE,MSTEP:CALL T_T
        LD HL,Mstop,DE,MSTOP:JP T_T
;-------
FIRST_S INC A:LD (INITZ+1),A:CALL DECODEx;Fast access to WC API (direct call's)

        LD A,1:CALL PRM_PL,NZ,oREPEAT;load options from wc.ini
        LD A,2:CALL PRM_PL,NZ,oMODE
        LD A,3:CALL PRM_PL,NZ,oSTOP

        LD HL,RND_INIres:CALL COD2RES;RND seed init
        RET
oREPEAT DEC A:LD (Mloop),A:RET
oMODE   DEC A:LD (Mstep),A:RET
oSTOP   DEC A:LD (Mstop),A:RET
;-------
DECODEx LD HL,(FUX)
        LD DE,3*2:ADD HL,DE
        LD E,(HL):INC HL
        LD D,(HL):INC HL:LD (PRSRWx+1),DE
        LD E,(HL):INC HL
        LD D,(HL):INC HL:LD (PRIATx+1),DE
        RET
;---------------------------------------
LOADtest LD HL,TESTend-TESTcod;size
         LD BC,TESTnm;name
         XOR A:LD E,A:EXA
         RET
LOADtst  LD HL,LOAD_TSTres:CALL COD2RES:LDIR
         RET
;---------------------------------------
WARNING CALL PLSHOW
        LD HL,WARNINGres,BC,(STA):CALL COD2RES
        DEC B
        RET
;---------------------------------------
HLPSHOW CALL HMD:JR Z,HLPshow
        XOR A:LD (HPMD),A,HL,HLPWNDrresb:JP COD2RES
HLPshow LD A,1,(HPMD),A,HL,HLPWNDprwow,DE,(HLPWNDxy):JP COD2RES
;---------------------------------------
PLGO    ;Play List position INIT
;        i:IX - PLWND
;          HL - position
;        o:NC - error
;           C - curpoz(IX+12),globY(IX+22/23),PLprintFLG(IX+24) init

        LD BC,HL
        LD DE,(PLcount):OR A:SBC HL,DE:RET NC;out of PL

;stay in same window position, if it possible (globY+curMAX>=HL>=globY):
        LD L,(IX+22)
        LD H,(IX+23)
        LD DE,BC
        EX DE,HL:OR A:SBC HL,DE
        EX DE,HL
        LD A,D:OR A:JR NZ,STAYnot
        LD A,E:CP (IX+13):INC A:JR C,STAYpoz

STAYnot LD HL,(PLcount),D,0,E,(IX+5):DEC E:OR A:SBC HL,DE:JR C,SHORTpz
        SRL E:LD HL,BC:OR A:SBC HL,DE:JR C,MIDpoz
        LD BC,HL,A,E:JR LONGpoz
MIDpoz  XOR A:SUB L:LD C,A
SHORTpz LD A,C,BC,0
LONGpoz INC A
        LD (IX+22),C
        LD (IX+23),B
STAYpoz LD (IX+12),A,(IX+24),1
        SCF
        RET
;-------
PLSHOW  ;Print/refresh PL window

        LD IX,PLWND,A,(IX+24):OR A:RET Z;PL refresh needed?
        DEC (IX+24)

        LD HL,#0101,(PLHL),HL;XY INIT
        XOR A:LD (LDR+1),A;PLend flag INIT

        LD L,(IX+22),H,(IX+23);globY
        LD B,(IX+5):DEC B:LD (IX+13),B;windowH-1=curMAX=rowCount
LSH     PUSH HL,BC:CALL PRLIN
        POP BC,HL:INC HL:DJNZ LSH
        RET
;-------
PRLIN   ;Print Line
;        i:    HL - globY
;          (PLHL) - XY
;        o:(PLHL) - Next row (Y=Y+1)

        PUSH HL:LD DE,(PLAYcur):OR A:SBC HL,DE
        POP HL

        PUSH AF
        CALL GWE
        CALL LDR:JR NC,LuR
        LD A," ",(DE),A:INC E:DJNZ $-2;Clear rest of line if needed

LuR     LD BC,PLW-2
        LD HL,(PLHL),DE,HL
        INC H:LD (PLHL),HL
        LD HL,SECBU:CALL PRSRWx;HL - Text; DE - XY; BC - Length
        POP AF:JR Z,$+6:LD A,MDC:JR $+4:LD A,CURclrP
        JP PRIATx
;-------
;Copy File Name to SECBU
LDR     LD A,0;PLend flag
        LD C,B
        LD B,PLW-2,DE,SECBU:OR A:SCF:RET NZ;is PL ended?

        LD B,A:ADD HL,BC
        LD BC,#5C+(128)*256;"/"+128b(max length)
        CALL MJ20X:INC HL;goto name start (without path)

        LD DE,SECBU,BC,14+(PLW-2)*256
MYJ     LD A,(HL):CP C:RET C:LD (DE),A:INC HL,E:DJNZ MYJ
        XOR A
        RET
;-------
Ldr     ;Copy Path to LOBU (512b MAX)
.2      LD A,(HL):CP C:RET C:LD (DE),A:INC HL,DE
        DJNZ Ldr
        XOR A
        RET
;-------
MJ20X   LD A,H:CP #C0:JR Z,MJ20x
MJ20    DEC HL:LD A,(HL)
        CP C:RET Z
        CP #D+1:RET C
        DJNZ MJ20
        RET

MJ20x   LD A,L:DEC HL:OR A:RET Z
        LD A,(HL)
        CP C:RET Z
        CP #D+1:RET C
        DJNZ MJ20x
        RET      
;-------
GWE     ;i:HL - globY
;        o:notEoPL: CHL - page+address
;                     B - length
;             EoPL: set (LDR+1) - ENDofPlayList and (IX+13) - curMAX

        LD A,(LDR+1):OR A:RET NZ;is PL ended?

        PUSH HL:CALL NPG
        POP HL

        LD DE,#C000
.2      ADD HL,HL
        ADD HL,DE

        LD C,(HL):INC L
        LD E,(HL):INC L
        LD D,(HL):INC L
        LD B,(HL):EX DE,HL
        LD A,H:CP #C0:JR NC,GWe

        LD A,1,(LDR+1),A
        LD A,(PLHL+1):DEC A
        LD (IX+13),A;curMAX
        RET

GWe     LD A,C,(PLPG),A:JP NPX
;-------
GWZ     ;i:none
;        o: C - error (out of PL)
;           Z - HL - address in page #C000-#FFFF (PLPG)
;               DE - track number

        LD IX,PLWND
        CALL NPG
        LD L,(IX+22),H,(IX+23)
        LD D,0,E,(IX+12):DEC E
        ADD HL,DE:LD (GLOBy+1),HL

        LD DE,#C000
.2      ADD HL,HL
        ADD HL,DE

        LD C,(HL):INC L
        LD E,(HL):INC L
        LD D,(HL):EX DE,HL
        LD A,H:CP #C0:RET C

        LD A,C,(PLPG),A
        CALL NPX
GLOBy   LD DE,0
        XOR A
        RET
;-------
PLINT   XOR A
        LD (IX+22),A
        LD (IX+23),A
        LD (PLAYcur+0),A
        LD (PLAYcur+1),A
        INC A
        LD (IX+12),A
        LD (IX+24),A
        RET
;---------------------------------------
MGENPL  CALL PLINI
        LD HL,0,(X+1),HL:CALL X
        JR PLEND

X       LD HL,0
        INC HL:LD A,H:CP 8:RET NC
        LD (X+1),HL:SET 7,H
        LD DE,SECBU:CALL TMRKDFL:RET NZ
        LD HL,SECBU:CALL GENLN
        JR X
;-------
PLINI   XOR A
        LD (PLPG),A
        LD HL,#C000
        LD (PLGE),HL
        LD (PLHL),HL
        RET

PLEND   CALL NPG
        XOR A
        LD HL,(PLGE)
.3      LD (HL),A:INC HL
        RET
;-------
GENLN   LD A,(PLPG):CALL NPX
        LD DE,(PLHL)
        LD BC,#FF0E
DLN
.2      LD A,(HL):CP C:JR C,SNDL:LD (DE),A:INC HL,DE
        DJNZ DLN
;error!
SNDL    LD A,#D,(DE),A

        PUSH HL,DE
        LD HL,(PLHL):EX DE,HL:OR A:SBC HL,DE:LD A,L,(PLED),A
        CALL NPG:LD DE,(PLGE),HL,PLPG,BC,4:LDIR:LD (PLGE),DE
        POP DE,HL:INC DE

        LD A,D:CP #FE
        LD A,(PLPG):JR C,NDL
        LD DE,#C000:INC A
NDL     LD (PLPG),A
        LD (PLHL),DE
        RET
;-------
PLPG    NOP ;- ! page and offset
PLHL    DS 2;/
PLED    NOP;/

PLGE    DS 2;offset in PL headers
;---------------------------------------
ONLY1TRACK LD HL,(PLGE),DE,#C000:OR A:SBC HL,DE:LD A,H:OR A:RET NZ:LD A,L:CP 4:RET
;-------
EXGENPL CALL PLINI
        LD HL,LOBU,B,8:CALL LOAD512
        LD HL,LOBU,DE,AYLH;check for AYL header
        CALL SRHMZ:LD DE,LOBU:JR NZ,M3;nope

        LD B,0:CALL MJ35;Skip Full Header (AYL)
        LD A,(HL):CP 10:JR NZ,$+3:INC HL
        EX DE,HL

M3      EX DE,HL:CALL CABOOM
        JP PLEND

CABOOM  XOR A:LD (LOBU-1),A

        LD DE,(PLGE)
OEE     LD A,H:CP LOBU[+#08:JR NC,TL
Oee     LD A,(HL)
        CP "<":JR Z,TWKL;AYL metadata skips
        CP "#":JR Z,TWKLM
OEe     CALL MJ30:JR NC,NEE

        LD A,(HL)
        CP #0A:JR NZ,$+3:INC HL
        LD A,(HL):OR A:JR NZ,OEE
NEE     RET
;-------
MJ30    CALL GENLN:LD A,(HL):OR A:RET Z:INC HL:SCF:RET
MJ35    LD A,(HL):INC HL:CP 14:RET C
        DJNZ MJ35
        RET

TL      LD BC,#0800:OR A:SBC HL,BC
        PUSH HL
        LD HL,LOBU+#0800
        LD DE,LOBU:LDIR

        EX DE,HL:LD B,4:CALL LOAD512
        POP HL
        JR Oee

TWKLM   INC HL
        LD A,(HL):INC HL
        LD B,(HL):DEC HL,HL
        CP "E":JR NZ,OEe
        LD A,B:CP "X":JR NZ,OEe
        JR TWK
TWKL    LD B,0:CALL MJ35
        LD A,(HL)
        OR A:JP Z,NEE
        CP #0A:JR NZ,$+3:INC HL
        LD A,(HL)
        CP ">":JR NZ,TWKL

TWK     LD B,0:CALL MJ35
        LD A,(HL)
        CP #0A:JR NZ,$+3:INC HL
        LD A,(HL):OR A:JR Z,NEE
        JP Oee
;---------------------------------------
TTT     LD C,1;Change to next and update
T_T     LD A,(HL):ADD A,C
        PUSH HL:INC HL
        LD C,(HL):INC HL
        LD B,(HL):INC HL:CP B:JR C,$+3:XOR A
        LD B,0
        PUSH AF
        OR A:JR Z,UUU:ADD HL,BC:DEC A:JR NZ,$-2
UUU     LDIR
        POP AF
        POP HL
        LD (HL),A
        RET
;---------------------------------------
NEED    LD HL,0
        LD (P_SH),HL,(TME),HL,(P_NU),HL

        CALL WINDZ,MNINF,ANFNT
        CALL PLRINF,PRINFO
        CALL PBCLC
        JP PBFCLR
;---------------------------------------
WINDZ   LD A,0:OR A:RET NZ
        INC A:LD (WINDZ+1),A

        LD A,(HEI)
        LD HL,MODE25,DE,6
        CP HEIMIN:JR Z,STLOAD
        LD HL,MODE30
        CP HEIMID:JR Z,STLOAD
        LD HL,MODE36; HEIMAX
STLOAD  LD A,(PLMD):OR A:JR NZ,KOTPLNO
        ADD HL,DE
        LD A,(HL),(PLWND+2),A:INC HL
        LD A,(HL),(PLWND+3),A:INC HL
KOTPLNO LD A,(HL),(MNWND+2),A:INC HL
        LD A,(HL),(MNWND+3),A:INC HL
        LD A,(HL),(ANWNDxy+0),A:INC HL
        LD A,(HL),(ANWNDxy+1),A:INC HL
        LD A,(HL),(HLPWNDxy+0),A:INC HL
        LD A,(HL),(HLPWNDxy+1),A

COMWIN  LD IX,MNWND:CALL PRWOW
FILEINF LD HL,0
        LD DE,MDW-2:ADD HL,DE:LD (HL),0:OR A:SBC HL,DE
        LD DE,#0701:CALL TXTPR

        LD HL,LINENIN,DE,#0600:CALL TXTPR

        LD HL,ANWNDprwow,DE,(ANWNDxy):CALL COD2RES
        LD IX,PLWND:CALL LMD,Z,PLPRWOW
        JP PLINT

PLPRWOW CALL PRWOW
;PLWINDOW Extension patch
        LD DE,(PLH-1)*256:CALL GADRW:LD (HL),#FE,A," "
         LD B,PLW-2:INC L:LD (HL),A:DJNZ $-2:INC L:LD (HL),#FF
        LD DE,PLH*256:CALL GADRW:LD A,%1111
         LD B,PLW,(HL),#F7:SET 7,L:LD (HL),A:RES 7,L:INC L:DJNZ $-8
        RET

MNINF   LD IX,MNWND
        LD HL,TXT1,DE,#0C01:CALL TXTPR
        LD HL,TXT2,DE,#0D01:CALL TXTPR

        LD HL,MZNM,DE,#0C09,BC,32:CALL PRSRWx
        LD HL,MZN2,DE,#0D09,BC,32:JP PRSRWx

PRINFO  LD IX,MNWND
        LD HL,PLT0,DE,#0901:CALL TXTPR
        LD HL,PLT1,DE,#0A01:CALL TXTPR

        LD A,#DF
        LD (SPR+#20+8),A
        LD (SPR+#20+18),A
        LD A,#DF
        LD (SPR+#40+8),A
        LD (SPR+#40+18),A
        RET

PLRINF  CALL NP1

        LD HL,PL0,B,26
        XOR A:LD (HL),A:INC HL:DJNZ $-2

        LD DE,(#C000)
        LD HL,PTI,B,17
AJ      LD A,(HL):INC HL:CP E:JR NZ,AL
        LD A,(HL):CP D:JR Z,A1J
AL      INC HL,HL,HL
        DJNZ AJ
        LD HL,PTIX-1
A1J     INC HL
        LD (NOWT),BC
        LD E,(HL):INC HL
        LD D,(HL)
        EX DE,HL
        LD DE,PL0,C,255
        LDI:LD A,(HL):OR A:JR NZ,$-4

        LD A,(SAAMZ):OR A:JR NZ,SAA
        LD HL,"MF"
        LD A,(FMMZ):OR A:JR NZ,A2J
        LD HL,"YA"
A2J     LD A,(TSMZ)
        OR A:JR Z,$+3:LD HL,"ST"
        LD (PL1),HL
        XOR A
A3J     LD (PL1+2),A
        RET
SAA     LD HL,"AS",(PL1),HL,A,H
        JR A3J
;---------------------------------------
ZAPUMZ  LD HL,#0100,(MUZPL),HL
        CALL AYOFF

        LD HL,PLAYM,(CTOL+1),HL
        LD HL,GTPR,B,64,A,32,(HL),A:INC HL:DJNZ $-2
        XOR A:LD (FMMZ),A,(SAAMZ),A

        LD HL,LOBU,DE,TFDFO;         TFD
        CALL SRHMZ:JP NZ,TRY0

        LD HL,LOBU+4,DE,GTPR
        LD B,32:CALL TFDFLL
        LD B,32:CALL TFDFLL

        LD A,3,(STA),A
        LD A,(TSFM):OR A:JP Z,NEmUZ
        LD (TRIG),A

        LD DE,TFDDL:CALL GETMZ
        LD HL,#C000+22,BC,TFDLN:CALL GETPL
        LD HL,0,(TFDPATCH),HL,(TFDPATCH2),HL

        LD HL,GTPR,(ONEB),HL
        LD HL,GTPR+32,(TWOB),HL

        LD A,TFDFLG,(FMMZ),A
        LD HL,PLAYTFD,(CTOL+1),HL

        CALL INSTM
        LD (L_HL),HL,(L_DE),DE
        XOR A:LD (L_A),A
        JP MUzz

PLAYTFD LD A,(EOM):OR A:RET Z
        LD A,(FMMZ):CP TFDFLG:CALL NZ,NP06
        LD HL,0
L_HL    EQU $-2
        LD DE,0
L_DE    EQU $-2
L_A     EQU $+1
        LD A,0:EXA:CALL TFDPLAY
        EXA:LD (L_A),A,(L_HL),HL,(L_DE),DE

        LD A,(FMMZ):CP TFDFLG:JR NZ,TFDLOAD
        LD HL,(TFDCUR):INC HL,HL
        LD A,(HL)
        CP #C0:RET NC
        CP #20:RET C
        SUB #22:LD (HL),A
        LD HL,FMMZ:INC (HL)
        LD HL,#2000,DE,#2000-#2200,BC,#200:LDIR
        RET
TFDLOAD LD HL,(TFDCUR):INC HL,HL
        LD A,(HL)
        CP #C2:RET NC
        CP #3C:RET C
        SUB #04:LD (HL),A
        LD HL,#3C00,DE,#3800,BC,#400:PUSH HL:LDIR:POP HL:LD B,2:JP LOAD512
;-------
TRY0    LD HL,LOBU,DE,HRFO;          HRUST
        CALL SRHMZ:JR NZ,TRY1
        LD A,(HL):AND %01111111
        CP "1":JR NZ,TRY1
        LD HL,(LOBU+4),A,H
        CP #50:JP NC,NEmUZ
        LD (DADE),HL

        LD HL,LOBU,DE,HL:CALL DEHR21

TRY1    LD HL,LOBU,DE,PTFO;          PT3
        LD A,1,(STA),A
        CALL ZATA:JP NZ,TRY1A
        XOR A:LD (VTMD),A

        LD DE,PTFO
        JP TSPT3

OTN     LD HL,0
        DEC HL
        LD DE,LOBU,BC,#6000
        LDIR

        LD A,(VTMD):OR A:JR Z,NVT
        LD DE,VTDL
        CALL GETMZ
        LD HL,#C000+24,BC,VTLN
        CALL GETPL

        LD HL,VTDL+30,(ONEB),HL
        LD HL,VTDL+66,(TWOB),HL
        JR JAZZ

NVT     LD A,(LOBU+98):CP #20:JR Z,NOTS
        LD A,2,(ZZMZ),A,(TSMZ),A

NOTS    LD DE,MMODUL
        CALL GETMZ

        LD HL,#C000+6,BC,PT3LN
        CALL GETPL

        LD HL,MMODUL+30,(ONEB),HL
        LD HL,MMODUL+66,(TWOB),HL

JAZZ    LD A,32,(#C00A),A

        LD A,5,(CTOL+1),A
MUZZ    CALL INSTM
;LD A,1,(P_ST),A
MUzz    LD HL,0,(TMM),HL

TRECH   LD A,(ZZMZ):OR A:JR NZ,GG
        LD HL,(TSFG),H,0
        LD (TSMZ),HL

GG      XOR A:LD (ZZMZ),A
        LD HL,1,(MUZPL),HL;PAUSEoff+PLAYactive

        CALL KOSHI
        CALL KPAH

        LD A,255,(ESTAT),A
        OR A
        RET

KPAH    LD HL,(ONEB),DE,MZNM,BC,32:LDIR
        LD HL,(TWOB),DE,MZNM+32,C,32:LDIR
        RET

NEmUZ   XOR A:LD (PAUS),A
        RET
;-------
KOSHI   ;LD A,1:LD (FILI),A
;XOR A:LD (ANCI),A
        RET

ZATA    LD (ZA+1),DE
        PUSH HL
        LD BC,(DADE)
        LD HL,LOBU:ADD HL,BC
        LD BC,HL
        POP HL
ZA      LD DE,PTFO
ZAT     LD A,H:CP B:JR Z,DOPC,NC,NTY    
DOpc    LD A,(DE)
        CP (HL):INC HL:JP NZ,ZAT
        LD (OTN+1),HL
MZMD    INC DE
        LD A,(DE):OR A:RET Z
        CP (HL):JR NZ,ZA
        INC HL
        JP MZMD
DOPC    LD A,L:CP C:JR C,DOpc
NTY     LD A,1:OR A
        RET

TRY1A   LD HL,LOBU,DE,VORT;          VTX
        CALL ZATA:JP NZ,TRY2
        LD A,1,(VTMD),A
        LD DE,VORT
TSPT3   LD HL,(OTN+1)
        PUSH HL
        LD BC,52:ADD HL,BC
        CALL ZATA:LD DE,(OTN+1)
        POP HL:LD (OTN+1),HL
AYPT3   JP NZ,OTN
        EX DE,HL
        DEC HL

        PUSH HL
        CALL NP8,NP06
        LD HL,LOBU,DE,#F000,BC,#1000
        LDIR

        LD HL,NP8,(LAG+1),HL
        LD HL,#C000+24,BC,VTLN
        CALL GETPL
        LD HL,NP1,(LAG+1),HL

        LD HL,#F000,DE,LOBU,BC,#1000
        LDIR
        POP HL

        EXX:LD DE,VTDL:EXX
        CALL ASS

        CALL INSTM
        LD A,1,(TSMZ),A,(TSFG),A
        LD HL,#C005,(CTOL2+1),HL

        CALL NP6
        JP OTN
ASS     LD B,48
CSS     PUSH BC
        CALL NP6
        LD DE,SECBU,BC,#0200:LDIR
        CALL NP8
        EXX:LD HL,SECBU,BC,#0200:LDIR
        EXX
        POP BC
        DJNZ CSS
        RET

TRY2    LD HL,LOBU,DE,TFMF;          TFC
        CALL ZATA:JP NZ,TRY2B

        LD A,2,(STA),A

        PUSH HL
        LD HL,(DADE),DE,LOBU
        ADD HL,DE
        POP DE
        OR A:SBC HL,DE
        EX DE,HL
        LD A,D:CP #60:JP NC,NEmUZ

        LD B,6
        LD A,(HL):INC HL
        CP "0":JP C,NEmUZ
        LD A,(HL)
        CP 50:JR Z,FFM
        CP 60:JP NZ,NEmUZ

FFM     INC HL,HL:LD A,(HL):CP #60:JP NC,NEmUZ:DJNZ FFM

        LD A,3,(STA),A
        LD A,(TSFM):OR A:JP Z,NEmUZ
        LD (TRIG),A

        LD HL,(OTN+1):DEC HL
        LD A,H
        CP #E0:JP NC,NEmUZ
        CP #40:JP C,NEmUZ
        LD DE,LOBU,BC,#6000;-FMPL
        LDIR

        LD DE,FMDL
        CALL GETMZ
        LD HL,#C000+20,BC,FMLN
        CALL GETPL

        LD HL,FMDL+#22
        LD A,(FMDL+8)
        CP "1":JR Z,$+5:LD HL,FMDL+#32

        LD DE,GTPR
        LD B,32:CALL TFDFLL
        LD B,32:CALL TFDFLL
        LD A,5,(FMMZ),A
        JP LUZZ+2

TFDFLL  LD A,(HL):OR A:JR Z,$+3:INC HL
        LD (DE),A:INC DE
        DJNZ TFDFLL
        INC HL
        RET

TRY2B   LD HL,LOBU,DE,ETFO;          SAA
        CALL ZATA:JR NZ,TRY2C

        LD HL,(OTN+1):DEC HL
        LD DE,0-10:ADD HL,DE
        LD DE,LOBU,BC,#4000
        LDIR

        LD A,1,(SAAMZ),A

        LD DE,ETDL
        CALL GETMZ

        LD HL,#C000+6,BC,ETLN
        CALL GETPL2

        CALL SAAON
        JP LUZZ

TRY2C   LD HL,LOBU+8,DE,PSMFO;       PSM
        CALL SRHMZ:JR NZ,TRY2A

        LD HL,(LOBU),BC,LOBU:ADD HL,BC
        LD A,#FF:CP (HL):JR Z,TRY2A
        LD B,63
PSMSLS  INC HL,HL:CP (HL):JR Z,PSMGO:DJNZ PSMSLS:JR TRY2A
PSMGO   LD A,64:SUB B:LD (PBSTP+1),A

        LD DE,PSMDL
        CALL GETMZ
        LD HL,#C000+8,BC,PSMLN
        CALL GETPL2
        JP LUZZ

TRY2A   LD IX,LOBU;                  STC
        LD A,(IX+#00):CP #CD:JR NZ,AST
        LD A,(IX+#01):CP #52:JR NZ,AST
        LD A,(IX+#02):CP #00:JR NZ,AST
        LD DE,#06E9
        JR STwPL
AST     LD A,(IX+#00):CP #21:JR NZ,BST
        LD A,(IX+#03):CP #C3:JR NZ,BST
        LD A,(IX+#06):CP #C3:JR NZ,BST
        LD A,(IX+#0A):CP #7E:JR NZ,BST
        LD DE,#043C
STwPL   ADD IX,DE

BST     LD A,(IX)
        OR A:JP Z,TRY3
        CP 24:JP NC,TRY3

        LD A,(IX+6):CP #28:JP NC,TRY3
        LD A,(IX+4):CP #20:JP NC,TRY3
        LD A,(IX+2):CP #10:JP NC,TRY3

        PUSH IX
        POP HL
        LD DE,7:ADD HL,DE
        LD B,18
SFT     LD A,(HL)
        CP #18:INC HL:JR C,MRK
        CP #20:JP C,TRY3
        CP #7B:JP NC,TRY3
MRK     DJNZ SFT

        PUSH IX
        POP HL
        LD E,27:ADD HL,DE
        LD A,(HL)
        OR A:JP Z,TRY3
        CP #12:JP NC,TRY3

KSA     CALL DETPT2:JR Z,TRY3

        PUSH IX
        POP HL
        LD DE,LOBU,BC,#4000-STLN
        LDIR

        LD DE,STDL
        CALL GETMZ

        LD HL,#C000+2,BC,STLN
        CALL GETPL

        LD HL,STDL+7,DE,GTPR,C,18;B=0
        LDIR
        JP LUZZ

DETPT2  LD A,(LOBU+131):INC A:JR Z,NET2
        LD HL,(LOBU+3),A,H:OR L:JR NZ,NET2

        LD HL,LOBU+3,B,32
ESAMP   LD A,(HL)
        INC HL:OR (HL):JR NZ,DAA2
        INC HL
        DJNZ ESAMP
        JR NET2

DAA2    LD D,(HL):DEC HL
        LD E,(HL)

        LD HL,(LOBU+67)
        LD BC,(LOBU+99)
        OR A:SBC HL,DE:JR C,NET2
        EX DE,HL
        XOR A:SBC HL,BC:JR C,NET2

        LD HL,LOBU+100,B,30-1
        INC HL:CP (HL):JR NZ,Daa2
        DJNZ $-4
        XOR A
        RET

Daa2    LD HL,LOBU+100
        LD A,30,B,A
DZDY    INC HL:CP (HL):JR NC,NET2
        DJNZ DZDY
        XOR A
        RET
NET2    LD A,1:OR A
        RET
TRY3    CALL DETPT2:JP NZ,TRY4;      PT2

        LD DE,PT2DL
        CALL GETMZ

        LD HL,#C000+4,BC,PT2LN
        CALL GETPL

        LD HL,PT2DL+101,DE,GTPR,C,30;B=0
        LDIR
LUZZ    LD A,6
        LD HL,GTPR,(ONEB),HL
        LD HL,GTPR+32,(TWOB),HL

        LD (CTOL+1),A
        JP MUZZ

AHHA    LD BC,HL
        LD DE,PSCDL
        ADD HL,DE
        ADD IX,DE
        EX DE,HL
        DEC IX,IX
AHH     LD A,(DE),L,A:INC DE
        LD A,(DE),H,A:DEC DE
        OR A:SBC HL,BC
        LD A,L,(DE),A:INC DE
        LD A,H,(DE),A:INC DE
        PUSH IX
        POP HL
        OR A:SBC HL,DE:JR NC,AHH
        RET

TRY4    LD HL,LOBU,DE,PSCFO;         PSC
        CALL SRHMZ:JR NZ,TRY5

        LD DE,PSCDL
        CALL GETMZ

        LD A,(PSCDL+8):CP "4":JR NC,PSC4

        LD HL,#4C,IX,(PSCDL+74)
        CALL AHHA
        LD HL,(PSCDL+74),IX,(PSCDL+69)
        CALL AHHA

PSC4    LD HL,#C000+8,BC,PSCLN
        CALL GETPL

        LD HL,PSCDL+25,DE,GTPR,C,20;B=0
        LDIR
        LD C,4
        ADD HL,BC
        LD DE,GTPR+32,C,20;B=0
        LDIR
        JP LUZZ

TRY5    LD HL,LOBU,DE,FTFO;           FT
        CALL SRHMZ:JP NZ,TRY6
        LD HL,LOBU+51
        INC DE
        CALL SRHMZ:JP NZ,TRY6

        LD DE,FTDL
        CALL GETMZ

        LD HL,#C000+10,BC,FTLN
        CALL GETPL

        LD HL,FTDL+8,DE,GTPR,C,42;B=0
        LDIR
        JP LUZZ

TRY6    LD HL,LOBU+10,DE,STPFO;      STP
        CALL SRHMZ:JP NZ,TRY7a

;LD HL,(OTN+1)
;LD BC,0-11:ADD HL,BC
;LD DE,LOBU
;LD BC,#4000-STPPL:LDIR

        LD A,1,(FLAG),A
SUPA    LD A,(LOBU+9):OR A:JR NZ,TBBS
        LD A,96,(LOBU+9),A

TBBS    LD DE,STPDL
        CALL GETMZ

        LD HL,#C000+12,BC,STPLN
        CALL GETPL

        LD A,(FLAG):DEC A:JP NZ,LUZZ
        LD HL,STPDL+38,DE,GTPR,C,25;B=0
        LDIR

        JP LUZZ

TRY7a   LD HL,LOBU
        LD A,(HL):INC HL
        OR A:JR Z,TRY8
        CP 24:JR NC,TRY8

        LD C,(HL):INC HL
        LD B,(HL):INC HL

        LD A,B:OR A:JR Z,TRY8
        CP #38:JR NC,TRY8

        LD A,3
TBS     LD E,(HL):INC HL
        LD D,(HL):INC HL
        EX DE,HL
        PUSH HL:OR A:SBC HL,BC
        POP BC:JR C,TRY8
        EX DE,HL
        EXA:LD A,B:CP #38:JR NC,TRY8
        EXA:DEC A:JR NZ,TBS
        LD A,2,(FLAG),A
        JP SUPA

TRY8    LD HL,LOBU+1,DE,GTFO;         GT
        CALL SRHMZ:JP NZ,TRY9

        LD DE,GTDL
        CALL GETMZ

        LD HL,#C000+14,BC,GTLN
        CALL GETPL

        LD HL,GTDL+7,DE,GTPR,C,32;B=0
        LDIR
        JP LUZZ

TRY9    LD HL,LOBU;                  ASC
        LD A,(HL):INC HL
        CP 3:JP C,TRYA
        CP #32+1:JP NC,TRYA
        LD A,(HL):INC HL
        CP #64+1:JP NC,TRYA

        LD BC,#0320
ASQ     LD A,(HL):INC HL
        OR (HL):JP Z,TRYA
        LD A,(HL):CP C:JP NC,TRYA
        LD A,C:ADD A,#10:LD C,A
        INC HL
        DJNZ ASQ

        LD A,(HL)
        OR A:JP Z,TRYA
        CP #64+1:JP NC,TRYA

        LD HL,(LOBU+2)
        LD DE,LOBU:ADD HL,DE

        LD C,(HL):INC HL
        LD B,(HL):INC HL
        LD E,(HL):INC HL
        LD D,(HL)
        EX DE,HL
        OR A:SBC HL,BC:JP C,TRYA

        LD DE,ASCDL
        CALL GETMZ

        LD HL,#C000+16,BC,ASCLN
        CALL GETPL

        LD HL,ASCDL,BC,128
TRB     LD A,B:OR C:JR Z,TRABL
        LD DE,ASCFO
        LD A,(DE)
        CPIR:JR NZ,TRABL
SRCT    INC DE
        LD A,(DE):OR A:JR Z,TRABL2
        CP (HL):JR NZ,TRB
        INC HL
        JR SRCT
TRABL2  LD DE,GTPR,BC,20:LDIR
        LD C,4:ADD HL,BC
        LD DE,GTPR+32,C,20:LDIR
TRABL   JP LUZZ

TRYA    LD HL,LOBU+1;                FLS
        LD B,64
PY      LD A,(HL):INC HL,HL
        CP #60:JR C,PYC
        DJNZ PY
PYC     LD A,B:CP 64-4:JR NC,TRYB
        LD A,(HL):CP #60:JR C,TRYB

        LD HL,(LOBU)
        LD DE,(LOBU+2)
        SBC HL,DE:JR C,TRYB

        LD DE,FLSDL
        CALL GETMZ

        LD HL,#C000+26,BC,FLSLN
        CALL GETPL
        JP LUZZ

TRYB    LD HL,LOBU,DE,FXFO;          FXM
        CALL SRHMZ:JR NZ,TRYC

        INC HL
        LD A,(HL):CP #60:JR C,TRYC

AYFXM   LD DE,FXDL
        CALL GETMZ

        LD HL,#C000+2,BC,FXLN
        CALL GETPL2
        JP LUZZ

TRYC    LD HL,LOBU;                  PT1
        LD A,(HL):CP 24:JR NC,TRYD
.3      INC HL
        LD A,(HL):INC HL
        OR (HL):JR NZ,TRYD

        LD HL,LOBU+69,B,30-1
BHG     LD A,(HL):INC HL
        CP #20:JR C,TRYD
        DJNZ BHG

AYPT1   LD DE,PT1DL
        CALL GETMZ

        LD HL,#C000+4,BC,PT1LN
        CALL GETPL2

        LD HL,PT1DL+69,DE,GTPR,C,30:LDIR
        JP LUZZ

TRYD    CALL NP6;                    SQT
        CALL SQTIDEN:JP NZ,NEmUZ

        LD HL,(DADE)
        LD DE,(LOBU),(DAR+1),DE
        SBC HL,DE:JR C,NTS
        LD A,H:CP 3
AYSQT   JR C,NTS

        CALL NP8
        LD HL,LOBU,DE,#E000,BC,#2000
        PUSH HL,DE,BC
        LDIR
        CALL GSQT,NP8
        POP BC,HL,DE
        LDIR
        CALL NP6

DAR     LD HL,0,DE,LOBU
        ADD HL,DE
        LD BC,#4000-SQLN
        LDIR

        CALL SQTIDEN:JR NZ,NTS+3
        LD HL,LOBU
        EXX:LD DE,SQDL:EXX
        CALL ASS

        LD HL,NP8,(LAG+1),HL
        LD HL,#C000+18,BC,SQLN
        CALL GETPL
        LD HL,NP1,(LAG+1),HL

        CALL INSTM
        LD A,1,(TSMZ),A,(TSFG),A
        LD HL,#C064,(CTOL2+1),HL
        JR NTS+3

NTS     CALL GSQT,NP1

        LD A,#64
        JP LUZZ+2

GSQT    LD DE,SQDL
        CALL GETMZ

        LD HL,#C000+18,BC,SQLN
        JP GETPL

SRHMZ   LD A,(DE):OR A:RET Z
        CP (HL):RET NZ
        INC HL,DE
        JR SRHMZ


GETPL2  CALL NPe:JR $+2+3
GETPL   CALL STN
        LD A,(HL):INC HL
        LD H,(HL),L,A
        LD DE,LOBU
        PUSH DE,BC
        DI
        CALL #C000;!
        EI
LAG     CALL NP1
        POP BC,HL
        LD DE,#C000
        LDIR
        RET

GETMZ   PUSH DE:CALL NP1
        POP DE
        LD HL,LOBU,BC,#2000:LDIR
        LD (DAHL),DE
        CALL NP6
        LD HL,#C000,DE,LOBU,BC,#2000:LDIR
        CALL NP1,NP062
        LD DE,(DAHL),HL,LOBU,BC,#2000:LDIR

        PUSH DE:CALL NP6
        POP DE: LD HL,#E000,BC,#2000:LDIR
        CALL NP1,NP062
        RET
;---------------------------------------
NOSQT   LD A,1:OR A
        RET
;IDENTIF
SQTIDEN LD IX,LOBU
        LD A,(IX+#00):CP #3E:JR NZ,NOPLR
        LD A,(IX+#02):CP #32:JR NZ,NOPLR
        LD A,(IX+#05):CP #32:JR NZ,NOPLR
        LD A,(IX+#08):CP #32:JR NZ,NOPLR
        LD A,(IX+#0B):CP #01:JR NZ,NOPLR
        LD HL,LOBU+SQLN
        LD DE,LOBU
        LD BC,#4000-SQLN
        LDIR

NOPLR   LD DE,(LOBU)
        LD A,D:CP #40:JR NC,NOSQT
        OR E:JR Z,NOSQT

        LD HL,LOBU-1:ADD HL,DE

        LD A,(HL):CP 9:JR NC,NOSQT
        DEC HL
        LD B,6
SQ1     LD A,(HL):OR A:JR NZ,NOSQT
        DEC HL
        DJNZ SQ1
        LD A,(HL)
        OR A:JR Z,NOSQT
        CP #21:JR NC,NOSQT

        XOR A
        RET
;---------------------------------------
ANFNT   LD A,0:OR A:RET NZ
        INC A:LD (ANFNT+1),A
        
        LD HL,FNTDECH
COD2RES EXA:LD A,COD2PG:JP RESIDENT_CALL

DEFNT   LD A,#FF:CALL MNGC_PL
        LD HL,#C800,DE,#C000,BC,8*20
        LDIR
        RET
;-------
ATIT    LD A,(TSFG):OR A:JR NZ,NEPL
        LD BC,(MUZPL)
        LD A,(GXMO):OR C:JR Z,NEPL
        LD A,C:OR A:JR Z,NEPL
        LD A,B:OR A:JR NZ,NEPL

        LD HL,(TME):INC HL:LD (TME),HL
        LD HL,(TMM):INC HL:LD (TMM),HL

        LD C,0:CALL TURBO
        CALL NP1,NP062
CTOL    CALL PLAYM
        LD A,(TSMZ):OR A:JR Z,NEPL
        CP 1:JR NZ,NEPL
        CALL NP8,NP06
        LD BC,#FFFD,A,#FE:OUT A
CTOL2   CALL PLAYM
        LD BC,#FFFD,A,#FF:OUT A
NEPL    LD C,2:JP TURBO
;-------
CLOCK   LD HL,(TMM),DE,CLOK
        LD BC,49*60,A,255
        OR A:INC A:SBC HL,BC:JP NC,$-3
        LD (DE),A:INC DE
        ADD HL,BC
        LD BC,49,A,255
        OR A:INC A:SBC HL,BC:JP NC,$-3
        LD (DE),A:INC DE
        ADD HL,BC
        LD A,L:ADD A,A
        LD (DE),A

        LD DE,SPR,A,(CLOK+0):CALL DEC0,PRDIS
        LD DE,SPR+10,A,(CLOK+1):CALL DEC0,PRDIS
        LD DE,SPR+20,A,(CLOK+2):CALL DEC0,PRDIS

        LD IX,MNWND
        LD HL,SPR+#00,DE,#0103,BC,27:CALL PRSRWx
        LD HL,SPR+#20,DE,#0203,BC,27:CALL PRSRWx
        LD HL,SPR+#40,DE,#0303,BC,27:CALL PRSRWx

        LD HL,SLINE,DE,#0401,BC,40:CALL PRSRWx
        LD HL,MODES,DE,#011F,A,(PLMD):DEC A:CALL NZ,TXTPR

        LD HL,SN1,A,(PBSTP+1):CALL NORK
        LD HL,SN2,A,(P_NU):CALL NORK
        
        LD HL,TXTSN1,DE,#0500:JP TXTPR

DEC0    LD C,#FF
        INC C:SUB 10:JR NC,$-3
        ADD A,10
        RET
;-------
;Print Digits
PRDIS   ;i: DE - Dest Address
;            C - Digit1
;            A - Digit2
  
        PUSH AF,DE
        CALL GDF
        POP DE,BC
        LD C,B
.4      INC DE

GDF     LD H,0,L,C
        PUSH HL
.3      ADD HL,HL
        POP BC
        ADD HL,BC;*9

        LD BC,DIGITS:ADD HL,BC
        LD A,3
DDF
.3      LDI
        EX DE,HL:LD BC,32-3:ADD HL,BC
        EX DE,HL
        DEC A:JR NZ,DDF
        RET
;---------------------------------------
PBLNE   LD A,(NOWT+1)
        CP 2:JR Z,PBVT
        CP 4:JR C,PBFCLR

PBVT    LD A,(P_NU):DEC A:CALL Z,PBCLR
        INC A
        LD H,0,L,A
.4      ADD HL,HL
        PUSH HL;*16
        ADD HL,HL
        PUSH HL;*32
.3      ADD HL,HL
;               *256
.2      POP BC:ADD HL,BC

PBSTP   LD DE,0
        LD A,D:OR E:JR Z,PBCLR
        LD BC,0-1
        OR A:INC BC:SBC HL,DE:JP NC,$-3

        LD HL,304
        OR A:SBC HL,BC
        JR NC,$+5:LD BC,304

        LD HL,PBLINE
        LD A,C
.3      SRL B:RR C
        JR Z,PBL
        LD B,C
FLPB    LD (HL),19:INC HL:DJNZ FLPB

PBL     AND 7:RET Z
        LD DE,PBTBL-1
        LD B,A:INC DE:DJNZ $-1
        LD A,(DE),(HL),A
        RET

PBFCLR  LD HL,PBLINE
        PUSH AF
        LD B,38,A,11
CFPB    LD (HL),A:INC HL:DJNZ CFPB
        POP AF
        RET

PBCLR   LD HL,PBLINE
        LD B,38
CLPB    LD (HL),11:INC HL:DJNZ CLPB
        RET

PBTBL   DB 12,13,14,15,16,17,18

PBCLC   CALL NP1
        LD A,(NOWT+1)
        ;CP 17:JR Z,PSMPB
        CP 15:JP Z,ET
        CP 14:JP Z,PT1
        CP 13:JP Z,PB11
        CP 12:JP Z,PB10
        CP 11:JP Z,PB9
        CP 10:JR Z,PB8
        CP 9:JR Z,PB7
        CP 8:JR Z,PB6
        CP 7:JR Z,PB5
        CP 6:JR Z,PB4
        CP 5:JR Z,PB3
        CP 4:JR Z,GTR
        CP 2:JR Z,FLS
        RET
;-------
FLS     LD HL,(FLSDL),DE,1:INC HL
        XOR A
        JR H0H-2

PB3     LD A,(VTDL+101)
        JR PB

PB4     LD HL,FTDL+212
        LD DE,2
        JR H00

PB5     LD HL,(PSCDL+71)
        LD DE,PSCDL+1:ADD HL,DE

        LD DE,8
H00     LD A,#FF
        LD B,0
H0H     CP (HL):JR Z,OH0
        ADD HL,DE
        DJNZ H0H
OH0     XOR A
        SUB B
        JR PB

PB6     LD HL,(SQDL+8),DE,6
        LD B,0
HoH     LD A,(HL):INC HL
        OR (HL)
        JR Z,$+5:ADD HL,DE:DJNZ HoH
        XOR A
        SUB B
        DEC A
.2      ADD A,A
        JR PB

PB7     LD IX,STPDL,E,0
        JR PB78
PB8     LD IX,STDL,E,1
PB78    LD C,(IX+1)
        LD B,(IX+2)
        ADD IX,BC
        LD A,(IX):ADD A,E
        JR PB

PB9     LD A,(ASCDL+8):DEC A
        JR PB

GTR     LD A,(GTDL+293)
        JR PB

PB10    LD A,(PT2DL+1)
        JR PB

PB11    LD A,(MMODUL+101)
PB      LD (PBSTP+1),A
        RET

PT1     LD A,(PT1DL+1):JR PB

ET      LD HL,(ETDL+0),DE,ETDL:ADD HL,DE
        LD BC,#00FF
HEH     LD A,(HL):CP C:JR Z,OHE
        INC HL:CP #60:JR NC,HEH
        DJNZ HEH
OHE     XOR A
        SUB B
        JR PB
;---------------------------------------
PMACH
SKSTC   LD HL,(MUZPL)
        LD A,L:OR A:RET Z
        LD A,H:OR A:JR NZ,NNX
        LD A,(PL0):OR A:RET Z
        CALL NP1
        LD A,(NOWT+1)
        CP 17:JP Z,PSM_A
        CP 16:JP Z,TFD_A
        CP 15:JP Z,ET_A
        CP 14:JP Z,PT1_A
        CP 13:JR Z,PT3_A
        CP 12:JR Z,PT2_A
        CP 11:JR Z,ASC_A
        CP 10:JR Z,STC_A
        CP 9:JR Z,STP_A
        CP 8:JR Z,SQT_A
        CP 7:JR Z,PSC_A
        CP 6:JR Z,FTC_A
        CP 5:JR Z,VTX_A
        CP 4:JR Z,GTR_A
        CP 3:JR Z,TFC_A
        CP 2:JR Z,FLS_A
;CP 1:JP Z,FXM_A
NNX     XOR A
        RET
BACKZ   LD HL,(P_SH)
        OR A:SBC HL,DE:JR Z,BCZ
        LD HL,0,(TME),HL
        LD HL,P_NU:INC (HL)

        LD A,(HL):CALL PBLNE

BCZ     LD A,(TME+1):CP 5:JR C,NNX
NXM     LD A,1:OR A
        RET

PT3_A   LD HL,(#C98B):JR LAA
PT2_A   LD HL,(#C2AB):JR LAA
SQT_A   LD HL,(#C08B+#34):JR LAA
PSC_A   LD HL,(#C0B6):JR LAA
FTC_A   LD HL,(#C0DA):JR LAA
VTX_A   LD HL,(#C00B)
LAA     CALL PKZ:JR C,NXM
LAZ     JR BACKZ

ASC_A   LD HL,(#C17C)
Laa     CALL PKz:JR C,NXM,LAZ

STC_A   LD HL,(#C0A0):JR Laa
STP_A   LD HL,(#C675):INC L:JR Laa
TFC_A   LD A,(#C008):OR A:JR NZ,NXM,NNX
TFD_A   LD A,(EOM):OR A:JR Z,NXM,NNX
FLS_A   LD HL,(#C299):JR Laa
GTR_A   LD HL,(#C23C+1):INC L:JR Laa
PSM_A   LD HL,(#C19E+1):JR Laa
;FXM_A HL,(#C109),DE,(P_SH)
;(P_SH),HL
;A,(#C009):OR A:JP NZ,NXM
;JP BACKZ
PT1_A   LD HL,(#C318+6):JR Laa
ET_A    LD HL,(#C462):JR LAA
;-------
PKz     LD H,0
PKZ     LD DE,(P_SH),(P_SH),HL
        OR A:SBC HL,DE
        RET
P_SH    DW 0
P_NU    DW 0
P_CH    NOP

ADiH    DW 0

BLIH    NOP ;0-STOP,1-ALL,2-ONE
;---------------------------------------
PRM_PL  EXA:LD A,83:JP WLD

MNGC_PL EXA:XOR A:JP WLD
PRWOW   LD A,1:JP WLD
RRESB   LD A,2:JP WLD
PRSRWx  JP 0
PRIATx  JP 0
GADRW   LD A,5:JP WLD
CURSOR  LD A,6:JP WLD
;CURSER  LD A,7:JP WLD
TXTPR   LD A,11:JP WLD
MEZZ    EXA:LD A,12:JP WLD
PB_PL   LD A,82:JP WLD

GEDPL   LD A,15:JP WLD
TURBO   LD B,#00,A,14:JP WLD
NORK    EXA:LD A,10:JP WLD
KBSCN   EXA:LD A,42:JP WLD
LOAD512 LD A,48:JP WLD
TENTRY  LD DE,SECBU,A,51:JP WLD
TMRKDFL LD IX,(DAIX),A,54:JP WLD
FENTRY  LD A,59:JP WLD
GFILE   LD A,62:JP WLD
;-------
SPKE    LD A,16:JP WLD
UPPP    LD A,17:JP WLD
DWWW    LD A,18:JP WLD
ENKE    LD A,22:JP WLD
ESC     LD A,23:JP WLD
F1KE    LD A,29:JP WLD
F2KE    LD A,30:JP WLD
F3KE    LD A,31:JP WLD
F4KE    LD A,32:JP WLD
;-------
NPe     LD A,2:EXA:XOR A:JP WLD
STN     LD A,1:EXA:XOR A:JP WLD

NP6     LD A,0:EXA:LD A,65:JP WLD;BUFFER (#C000)
NP06    LD A,3:EXA:LD A,80:JP WLD;BUFFER2 (#0000)
NP62    LD A,4:EXA:LD A,65:JP WLD;BUFFER3 (#C000)
NP062   LD A,4:EXA:LD A,80:JP WLD;BUFFER3 (#0000)
NP1     LD A,1:EXA:LD A,65:JP WLD;MDL1 (#C000)
NP8     LD A,2:EXA:LD A,65:JP WLD;MDL2 (#C000)

NPG     LD A,PLHDRS:EXA:LD A,65:JP WLD;PLHDRS
NPX     PUSH HL,DE,BC
        ADD A,PLHDRS+1:EXA:LD A,65:CALL WLD
        POP BC,DE,HL
        RET
;-------
WAIT    PUSH BC:LD B,0:DJNZ $
        POP BC
        RET

TFMDET  XOR A:LD (DETKA),A
        LD BC,#FFFD,A,%11111000:OUT A:CALL WAIT
        XOR A:OUT A:CALL WAIT
        LD B,#BF:OUT B:CALL WAIT
        LD B,#FF:INF:LD A,1:JP P,FM_EN
        XOR A
FM_EN   LD (TSFM),A
;-------
SAAON   CALL SAAOFF
        LD BC,#FFFD,A,#F6:OUT A
        RET
SAAOFF  LD BC,#00FF
        XOR A:LD E,A
BAROQUE INC B:OUT A
        DEC B:OUT E
        INC A:CP 32:JR C,BAROQUE
        RET

AYOFF   CALL SAAOFF

        LD BC,#FFFD,A,#FE:OUT A
        PUSH BC:CALL AYFF
        POP BC
        LD A,#FF:OUT A

AYFF    XOR A
        LD BC,#FFFD,D,8:OUT D
        LD E,B
        LD B,#BF:OUT A
        LD B,E:INC D:OUT D
        LD B,#BF:OUT A
        LD B,E:INC D:OUT D
        LD B,#BF:OUT A
;Noize:
        LD A,%00111111
        LD B,E,D,7:OUT D
        LD B,#BF:OUT A
        RET
;---------------------------------------
;Wild Player plugin
;---------------------------------------
MODE25  DB MDXzero,MDY25,MDXzero,ANY25,HLPX25,HLPY25
        DB PLX,PLY25,MDX,MDY25,ANX,ANY25,HLPX25,HLPY25
MODE30  DB MDXzero,MDY,MDXzero,ANY,HLPX,HLPY
        DB PLX,PLY,MDX,MDY,ANX,ANY,HLPX,HLPY
MODE36  DB MDXZ36,MDY36,MDXZ36,ANY36,HLPX36,HLPY36
        DB PLX36,PLY36,MDX36,MDY36,ANX36,ANY36,HLPX36,HLPY36
;-------
MNWND   DB 4+16+128,0
        DB MDX,MDY;    X,Y
        DB MDW,MDH;    W,H
        DB MDC;        PAPER+INK
        DB 0
        DW #0000;      BUFFER
        DB 3,6;        LINES

        DW MNTXT
        DW 0
        DW 0

MNTXT   DB #E,#9,"Wild Player Plugin v1.84",0
;---------------------------------------
PLWND   DB 5+16+128,CURmsk
        DB PLX,PLY;    X,Y
        DB PLW,PLH;    W,H
        DB MDC;        PAPER+INK
        DB 0
        DW #0000;      BUFFER
        DB 0,0;        LINES

        DB 1;     +11  curNOW
        DB PLH-2; +12  curMAX
        DB CURclr;     curCOLOR
        DB MDC;        UNDcur

        DW PLTXT
        DW 0
        DW 0

        DW 0;+22       GLOBAL Y
        DB 0;+24       PRINTflg

PLTXT   DB #E
        DB #9,"Play List"
        DB 0
;---------------------------------------
PTI     DB #21,#94:DW PLIH;PSM
        DB #C3,#0E:DW PLIG;TFD
        DB #21,#B3:DW PLIF;SAA
        DB #21,#C6:DW PLIE;PT1
        DB #21,#E1:DW PLI1;PT3
        DB #21,#0C:DW PLI2;PT2
        DB #18,#0A:DW PLI4;ASC
        DB #21,#3C:DW PLI5;STC
        DB #21,#68:DW PLI6;STP
        DB #3E,#08:DW PLI7;SQT
        DB #21,#AB:DW PLI8;PSC
        DB #21,#05:DW PLI9;FTC
        DB #21,#6E:DW PLI3;VTX
        DB #21,#9A:DW PLIA;GTR
        DB #21,#3D:DW PLIB;TFC
        DB #21,#E6:DW PLIC;FLS
        DB #C3,#09:DW PLID;FXM
PTIX    DW PLIX
NOWT    DW 0
;-------
PLI1    DB "Pro Tracker v3.x       ",0
PLI2    DB "Pro Tracker 2          ",0
PLI3    DB "Vortex Tracker II      ",0
PLI4    DB "ASC Sound Master       ",0
PLI5    DB "Sound Tracker          ",0
PLI6    DB "Sound Tracker Pro      ",0
PLI7    DB "SQ Tracker             ",0
PLI8    DB "Pro Sound Creator v1.0x",0
PLI9    DB "Fast Tracker v1.0x     ",0
PLIA    DB "Global Tracker         ",0
PLIB    DB "TFM Compiler v1.x      ",0
PLIC    DB "FLASH Tracker          ",0
PLID    DB "Fuxoft AY Language     ",0
PLIE    DB "Pro Tracker 1          ",0
PLIF    DB "E-Tracker              ",0
PLIG    DB "TFM unpacked           ",0
PLIH    DB "Pro Sound Maker        ",0
PLIX    DB 32,0
;-------
DIGITS  DB #DC,#DC,#DC;0
        DB #DB,#20,#DB
        DB #DB,#DC,#DB
        DB #20,#DC,#20;1
        DB #DF,#DB,#20
        DB #DC,#DB,#DC
        DB #DC,#DC,#DC;2
        DB #DC,#DC,#DB
        DB #DB,#DC,#DC
        DB #DC,#DC,#DC;3
        DB #20,#DC,#DB
        DB #DC,#DC,#DB
        DB #DC,#20,#DC;4
        DB #DB,#DC,#DB
        DB #20,#20,#DB
        DB #DC,#DC,#DC;5
        DB #DB,#DC,#DC
        DB #DC,#DC,#DB
        DB #DC,#DC,#DC;6
        DB #DB,#DC,#DC
        DB #DB,#DC,#DB
        DB #DC,#DC,#DC;7
        DB #20,#20,#DB
        DB #20,#20,#DB
        DB #DC,#DC,#DC;8
        DB #DB,#DC,#DB
        DB #DB,#DC,#DB
        DB #DC,#DC,#DC;9
        DB #DB,#DC,#DB
        DB #DC,#DC,#DB
;-------
PTFO    DB "ProTracker 3.",0
VORT    DB "Vortex Tracker II 1.",0
TFMF    DB "TFMcom1.",0
ETFO    DB "ETracker (C) BY ESI",0
PSMFO   DB "psm1",0
STPFO   DB "KSA SOFTWARE COMPILATION OF"
        DB 0
PSCFO   DB "PSC V1.0",0
FTFO    DB "Module: ",0
        DB "Fast Tracker v1.",0
ASCFO   DB "ASM COMPILATION OF ",0
GTFO    DB "GTR",0
FXFO    DB "FXSM",0

AYLH    DB "ZX Spectrum Sound Chip "
        DB "Emulator Play List File "
        DB "v1.",0
;---------------------------------------
MODES   DB " F2",5,5,#FE:DW MLOOP:DB 13
        DB " F3",5,5,#FE:DW MSTEP:DB 13
        DB " F4",5,5,#FE:DW MSTOP
        NOP

MLOOP   DB "   ",0
Mloop   DB #0,3,2
        DB "ALL"
        DB "ONE"

MSTEP   DB "       ",0
Mstep   DB #0,7,3
        DB "FORWARD"
        DB "BCKWARD"
        DB "SHUFFLE"

MSTOP   DB "    ",0
Mstop   DB #0,4,2
        DB "PLAY"
        DB "STOP"
;-------
PLT0    DB 2," Editor:"
        DB 7,7
PL0     DB "                          "
        DB 0
PLT1    DB 2,"   Mode:"
        DB 7,7,#FE:DW PL1
        DB " track",0
PL1     DB "   ",0

CLOK    DB 0,0,0

SLINE   DB 9
PBLINE  DS 38,32
        DB 10
CLK     DB "00:00.00"

MZNM    DS 32
MZN2    DS 32
GTPR    DS 64

TXT1    DB 1,"   Name:",0
TXT2    DB 1," Author:",0

TXTSN1  DB #E,"Position: ","#"
SN2     DB "00  Length: ","#"
SN1     DB "00",0

TME     DS 2
TMM     DS 2

SSTAT   NOP
ESTAT   NOP
DETKA   DB 1

P_ST    NOP

TSFM    NOP
TRIG    NOP

GXMO    NOP
STA     NOP
FMMZ    NOP;FM Modes
SAAMZ   NOP
TSMZ    NOP;TS Mode
TSFG    NOP
ZZMZ    NOP
VTMD    NOP

FLAG    NOP

PLMD    NOP ;Play List Flag
HPMD    NOP ;Help Window Flag

MUZPL   NOP
PAUS    NOP
ONEB    DS 2
TWOB    DS 2

DAHL    DS 2
DADE    DS 2
DAIX    DS 2

EXTNUM  NOP

ANWNDxy  DS 2;-Coordinates buffer 4 resident
HLPWNDxy DS 2;/

PLcount DS 2;Entrys in PL
PLAYcur DS 2;Play cursor

TFDFO   DB "TFMD",0
HRFO    DB "hr2",0
;-------
DEHR21  INCB "DEHR21.COD"
TESTnm  DB "test.pt3",0
;-------
LINENIN DB #E:DS 16,#C4:DB 0
;-------
SPR     DS 32*3
END
;---------------------------------------
        ORG PLAYER1
        INCB "PLAYERZ7.COD"
        ORG PLAYER2
        INCB "PLAYERS9.COD"
;---------------------------------------
            ORG #8000,COD2;Residential area
STARTCOD2
;TEMP variables:
TSMZres     NOP
FMMZres     NOP
SAAMZres    NOP

;WC calls used from resident:
MNGC_PLres  EXA:XOR A:JP WLD
PRWOWres    LD A,1:JP WLD
RRESBres    LD A,2:JP WLD
PRSRWres    LD A,3:JP WLD
TXTPRres    LD A,11:JP WLD
MEZZres     EXA:LD A,12:JP WLD
SPKEres     LD A,16:JP WLD
ENKEres     LD A,22:JP WLD
ESCres      LD A,23:JP WLD

;Functions used from main:
HLPWNDprwow LD (HLPWND+2),DE
            LD IX,HLPWND:JP PRWOWres
HLPWNDrresb LD IX,HLPWND:JP RRESBres
;-----------
ANWNDprwow  LD (ANWND+2),DE
            LD IX,ANWND:JP PRWOWres
ANWNDrresb  LD IX,ANWND:JP RRESBres
ANALYZEanpr EXA:LD (TSMZres),A,(FMMZres),BC
            CALL ANALYZE,ANPR
            RET
;-----------
RND_INIres  LD A,R:OR 128:LD (SEEDrnd),A:RET
RND_GENres  ;i:BC - MAX value
;            o:BC - RND(0-MAX)

            LD B,C
            CALL RND:SUB B:JR NC,$-1:ADD A,B:LD C,A
            LD B,0
            RET
;-----------
LOAD_TSTres LD HL,TESTcod,DE,#C000,BC,TESTend-TESTcod
            PUSH DE,BC:LDIR
            POP BC,HL
            LD DE,LOBU
            RET
;-----------
WARNINGres  ;i:C - error message
;            o:B - 0 - exit to commander
;                  1 - go to next track anyway (time out/ENTER)

            PUSH BC:LD IX,ERRWND:CALL PRWOWres
            POP BC
            LD A,C,HL,ERRORS,DE,#0101:CALL MEZZres
            CALL WARNINGwTO
            PUSH BC:CALL RRESBres
            POP BC
            RET
;-----------
LOADINGprwow LD IX,LOADWND:JP PRWOWres
LOADINGrresb LD IX,LOADWND:JP RRESBres

;---------------------------------------
;FONT DECRUNCH
;---------------------------------------
FNTDECH
;Pitch:
        LD A,#FF:CALL MNGC_PLres
        LD HL,#C000,DE,#C800,BC,8*20
        LDIR
        LD HL,#C000,DE,#C001,BC,8*20-1
        LD (HL),L
        LDIR

        LD HL,#C000+8+7,DE,8
        LD C,%01111110
        LD A,1
AFN     PUSH HL:LD B,A,(HL),C:DEC HL:DJNZ $-2
        POP HL:ADD HL,DE
        INC A:CP 9:JR C,AFN
;Noize:
        LD HL,#C000+8*NZ0CHAR,DE,%00000000 11111111
        LD B,6
NOIZEE  LD (HL),%11111111:INC L
        LD A,B:SUB 6:JR Z,NZ1
        LD C,A:XOR A:SUB C
        LD C,B,B,A
        LD (HL),E:INC L:DJNZ $-2
        LD B,C
NZ1     LD C,B
        LD (HL),D:INC L:DJNZ $-2
        LD B,C
        LD (HL),%11111111:INC HL
        DEC B:JR NZ,NOIZEE
;Progressbar:
        LD HL,PBRMK,DE,#C000+8*9,BC,8*3:LDIR
        LD HL,DE,BC,0-8:ADD HL,BC
        LD BC,8*8:LDIR

        LD A,%10000000
        LD B,8,HL,#C000+8*12+3,DE,8-1
BUR     LD C,A:OR (HL):LD (HL),A:INC L
        LD A,C:OR (HL):LD (HL),A
        LD A,C
        ADD HL,DE
        SCF:RRA
        DJNZ BUR
        RET

;---------------------------------------
;AY/YM Analizer
;---------------------------------------
ANPR    LD IX,ANWND
        LD HL,VZL1,DE,#0101,BC,40:CALL PRSRWres
        LD HL,VZL2,DE,#0201,BC,40:CALL PRSRWres
        LD HL,VZL3,DE,#0301,BC,40:JP PRSRWres
;-------
FRQSRL
;Noize
        LD HL,VZL3+4
.32     LD A,(HL):CP NZ0CHAR:JR Z,$+3:DEC (HL):INC HL
;Pitch
        LD HL,VZL1,DE,VZL2,B,40
JAJA    LD A,(HL):OR A:JR Z,AJA:DEC (HL)
A_A     INC HL,DE:DJNZ JAJA
        RET
AJA     LD A,(DE):SUB 1:JR C,A_A:LD (DE),A
        JP A_A
;-------
NOIZE   LD BC,#FFFD
        LD A,7:OUT A:IN A:AND %00111000:XOR %00111000:RET Z;no noise
        LD A,6:OUT A:IN A:AND %00011111
        LD HL,VZL3+4,D,0,E,A:ADD HL,DE
        LD (HL),NZHCHAR
        RET
;-------
ANALYZE CALL FRQSRL

        LD BC,(FMMZres)
        LD A,B:OR A:RET NZ
        LD A,C:OR A:JR NZ,FMman
        LD A,(TSMZres):OR A:JR Z,LYZA
        LD BC,#FFFD,A,#FE:OUT A:CALL LYZA
        LD BC,#FFFD,A,#FF:OUT A

LYZA    CALL NOIZE

        LD DE,#108:CALL CHANL
        LD DE,#309:CALL CHANL
        LD DE,#50A:JP CHANL
;-------
KED     DS 3
;-------
FMman   LD A,15,BC,(KED):CALL KEDY
        LD A,15,BC,(KED),HL,40-1:OR A:SBC HL,BC:LD BC,HL:CALL KEDY

        LD A,(KED+2):OR A:JR NZ,KEDdec
        LD HL,KED:INC (HL):LD A,(HL):CP 40:RET C
        LD (HL),40-1,(KED+2),A
        RET
KEDdec  LD HL,KED,A,(HL):OR A:JR Z,$+4:DEC (HL):RET:LD (KED+2),A:RET
;-------
CHANL   LD BC,#FFFD
        OUT D;REG Sel (Pitch Hi)
        IN A:AND %00001111:LD H,A
        DEC D:OUT D;REG Sel (Pitch Lo)
        IN A:LD L,A
        OUT E;REG Sel (Volume)
        IN A:AND %00001111
        LD BC,HL

        EXA
        LD HL,ANALYZR,A,40
PYZDEK  LD E,(HL):INC HL
        LD D,(HL):INC HL
        EX DE,HL:SBC HL,BC
        EX DE,HL:DEC A:JP C,PYZDEK
        LD B,0,C,A
        EXA

KEDY    LD HL,VZL1:ADD HL,BC:LD C,40
        CP 9:JR C,TYN
        SUB 8:LD (HL),A
        LD A,8
TyN     ADD HL,BC:LD (HL),A
        RET
TYN     LD (HL),0
        JR TyN
;-------
ANALYZR DW 12,15,18,21,25,30,35,42,50,59
        DW 71,84,100,119,141,168,200,238,283,336
        DW 400,476,565,672,800,951,1131,1345,1599,1902
        DW 2262,2539,2690,2850,3019,3199,3389,3590,3803
        DW 65535;40

;---------------------------------------
;RND generator
;---------------------------------------
SEEDrnd EQU RND+1
RND     LD HL,#FFFF:ADD HL,HL:SBC A,A:AND #EB
        LD C,A
        XOR L:LD L,A,A,C:XOR H:LD H,A,(SEEDrnd),HL

        AND %10101010:ADD A,L
        RET

;---------------------------------------
;Module Error Time-OUT
;---------------------------------------
WARNINGwTO  LD BC,TimeOut,(TIME_OUT+1),BC
Wait        EI:HALT
            CALL TIME_OUT:LD B,1:RET NC
            CALL ESCres:LD B,0:RET NZ
            CALL ENKEres:LD B,1:RET NZ
            CALL SPKEres:LD B,1:RET NZ
            JR Wait

TIME_OUT LD BC,0:DEC BC:LD (TIME_OUT+1),BC
         LD A,B:OR C:RET Z
         LD HL,BC,DE,Frames
         XOR A
         LD A,"0"
SUB      SBC HL,DE:INC A:JR NC,SUB
         DEC A:LD (WAITSEC),A
         LD HL,WAITING,DE,#0201:CALL TXTPRres
         SCF
         RET

;---------------------------------------
;Progress BAR chars:
PBRMK   DB %00000000
        DB %00000111
        DB %00000110
        DB %00000110
        DB %00000110
        DB %00000110
        DB %00000111
        DB %00000000

        DB %00000000
        DB %11100000
        DB %01100000
        DB %01100000
        DB %01100000
        DB %01100000
        DB %11100000
        DB %00000000

        DB %00000000
        DB %11111111
        DB %00000000
        DB %10101010
        DB %01010101
        DB %00000000
        DB %11111111
        DB %00000000
;---------------------------------------
ANWND   DB 4+16+128,0
        DB ANX,ANY;    X,Y
        DB ANW,ANH;    W,H
        DB MDC;        PAPER+INK
        DB 0
        DW #0000;      BUFFER
        DB 0,0;        LINES

        DW ANTXT
        DW 0
        DW 0

ANTXT   DB #0B,1,#9,"F1 - Help  M - Pause  SPACE - Next track",0
;---------------------------------------
HLPWND  DB 4+16,0
        DB HLPX,HLPY;  X,Y
        DB HLPW,HLPH;  W,H
        DB HLPC;       PAPER+INK
        DB 0
        DW #0000;      BUFFER
        DB 0,0;        LINES

        DW HLPTOP
        DW HLPBOT
        DW HLPTXT

HLPTOP  DB #E,#9,"Help",0
HLPBOT  DB #B,1,#9,"F1 - Hide this Window",0
HLPTXT  DB #E,"SPACE - play next file",13
        DB #E,"ENTER - play file under cursor (play list mode)",13
        DB #E,"UP/DOWN - select file (play list mode)",13
        DB #E,"F2/F3/F4 - REPEAT type/ORDER mode/PLAYstop (play list mode)"
        DB 0
;---------------------------------------
ERRWND  DB 4+16,0
        DB 255,255;    X,Y
        DB ERRW,ERRH;  W,H
        DB ERRC;       PAPER+INK
        DB 0
        DW #0000;      BUFFER
        DB 0,0;        LINES

        DW ERRTOP
        DW ERRBOT
        DW 0

ERRTOP  DB #E,#9,"Warning!",0
ERRTXT  ;Error message
        ;WAITING
ERRBOT  DB #9,"Press ENTER to continue or ESC - to exit",0

ERRORS  DB #E,"0",0,0;0
        DB #E,"Unknown module!!!",0,0;1
        DB #E,"TFC invalid!!!",0,0;2
        DB #E,"TSFM detect failed!!!",0,0;3

WAITING DB #E,"Starting next file in "
WAITSEC DB "9"," seconds",0
;---------------------------------------
LOADWND DB 4+16,0
        DB 255,255;    X,Y
        DB LOADW,LOADH;W,H
        DB LOADC;      PAPER+INK
        DB 0
        DW #0000;      BUFFER
        DB 0,0;        LINES

        DW LOADTOP
        DW 0
        DW LOADTXT

LOADTOP DB #E,#9,"Loading!",0
LOADTXT DB #E,"Please wait...",0
;---------------------------------------
VZL1    DS 40,8;- AY/YM Analisator
VZL2    DS 40,8;/
VZL3    DS 40,NZ0CHAR;Noize
;---------------------------------------
TESTcod INCB "test.pt3.cdb"
TESTend
;---------------------------------------
ENDCOD2
;---------------------------------------
STLN    EQU 1084
PT2LN   EQU 2459
PT3LN   EQU #BE1
PSCLN   EQU 2987
FTLN    EQU 3077
STPLN   EQU 1896
GTLN    EQU 1690
ASCLN   EQU 1458
SQLN    EQU 1348;1296
FMLN    EQU #73D;43
VTLN    EQU #651
FLSLN   EQU #5E6
FXLN    EQU #511
PT1LN   EQU #6C6
ETLN    EQU 1203
TFDLN   EQU #200
PSMLN   EQU #494
;-------
MMODUL  EQU #C000+PT3PL
PT2DL   EQU #C000+PT2PL
STPDL   EQU #C000+STPLN
STDL    EQU #C000+STLN
PSCDL   EQU #C000+PSCLN
FTDL    EQU #C000+FTLN
GTDL    EQU #C000+GTLN
ASCDL   EQU #C000+ASCLN
SQDL    EQU #C000+SQLN
FMDL    EQU #C000+FMLN
VTDL    EQU #C000+VTPL
FLSDL   EQU #C000+FLSLN
FXDL    EQU #C000+FXLN
PT1DL   EQU #C000+PT1LN
ETDL    EQU #C000+ETLN
TFDDL   EQU #C000+TFDLN
PSMDL   EQU #C000+PSMLN
;---------------------------------------
