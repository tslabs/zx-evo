;Text & HEX Viewer & Editor
;(C) KOSHI/MGN 2026
;---------------------------------------
 SAVEBIN "re.wmf"
;---------------------------------------
vREa     EQU "0."
vREb     EQU "28"
;--------
         ORG #0
;-------
WLD      EQU #6006; Plugin System Call Point
TMN      EQU #6009; Timer
HEI      EQU #600E
FUX      EQU #6026

LOBU     EQU #B000

TVBPG    EQU 0
TVEPG    EQU TVBPG+63
;-------
SRHSTRLN EQU 40;SEARCH STRING LENGHT
;-------
TVWNDcolor EQU %00010111
;---------------------------------------
;Plug-in Header:
        DS      16;  reserved
        DB      "WildCommanderMDL";
        DB      #11; v0.17 of Plug-in system
        DB      0;   reserved
;-------
        DB      1; Pages
        DB      0; Page to #8000
;-------
        DB      0,1+(ENDPL-RE)/512
.5      DB      0,0
;-------
        DS      15;  reserved
;-------ExtExeType:
        DB      %11; F3 Only
;-------Exts:
        DB      "TXT";0
        DB      "WRD";1
        DB      "INI";2
        DB      "INF";3
        DB      "HTM";4
        DB      "A80";5
        DB      "ASM";6
        DB      "DIZ";7
        DB      "NF0";8

        DB      "BIN";9
BINEXT  EQU     9
        DB      "NFO";10
.21     DS      3
        DB      0
;-------
        DW      #000F,#BFFF; max file size
;-------
        DB      "Text&HEX Viewer v",vREa[,vREa],vREb[,vREb],"           "
        DB      5; by Extension & by F3 or by F10 menu
;-------
        DS      6
;-------
        DB      "View as Text or BIN     "
;-------
        DS      284
;---------------------------------------
        ORG #8000,$
RE      LD (BUX),BC
        LD (DAHL),HL,(DADE),DE,(TYPE),A

        CALL INIT
        CALL DECODEx

        CP 3:JP Z,BYF10
        CP 4:JR NZ,BYEXT
BYGREEN CALL LOADnPR
        CALL ANALYZE:JP Z,VBIN
BYEXT   EXA
        CALL LOADnPR:CP BINEXT:JP Z,VBIN

RERE    CALL CHEBUREK
        ;CALL COLORING_TXT
        CALL PGPR
REMAIN  EI:HALT

        ;CALL SEARCH_:JR NZ,REMAIN
        CALL TABK:JP NZ,VBIN

        CALL UPPP,NZ,TVUP
        CALL DWWW,NZ,TVDN
        CALL PGU,NZ,TVPGUP
        CALL PGD,NZ,TVPGDN

        CALL F1,NZ,HELP
        CALL SPKE:JR NZ,REEX
        CALL ESC:JR NZ,REEX
        JR REMAIN

REEX    CALL DEINIT
        CALL RRESB
        XOR A
        RET
;-------
DECODEx LD HL,(FUX)
        LD DE,3*2:ADD HL,DE
        LD E,(HL):INC HL
        LD D,(HL):INC HL:LD (PRSRWx+1),DE;3
        LD E,(HL):INC HL
        LD D,(HL):INC HL:LD (PRIATx+1),DE;4
        LD E,(HL):INC HL
        LD D,(HL):INC HL:LD (GADRWx+1),DE;5
        LD E,(HL):INC HL
        LD D,(HL):INC HL;6
        LD DE,(65-7)*2:ADD HL,DE
        LD E,(HL):INC HL
        LD D,(HL):INC HL:LD (MNGCVPLx+1),DE;65
        RET
;-------
LOADnPR PUSH AF
        CALL REK
        LD IX,TVWND:CALL PRWOW
        CALL TVHEAD
        POP AF
        RET
;---------------------------------------
HELP    PUSH IX
        LD IX,F1WND:CALL PRWOW
        CALL USPO
        CALL NUSP
        CALL RRESB
        POP IX
        RET
;---------------------------------------
SAVE_FILE LD A,(TYPE):CP 3:RET Z;no DIR's

          PUSH IX
          LD IX,YNWND:CALL PRWOW

          LD A,2:CALL YN
          EI:HALT:XOR A:CALL YN:CALL USPO
YNMAIN    EI:HALT:XOR A:CALL YN

          CALL ESC:JR NZ,NOsave
          CALL ENKE:JR Z,YNMAIN
          LD A,#FF:CALL YN:JR NZ,NOsave
          CALL RRESB

          LD IX,SVWND:CALL PRWOW
;---------
          CALL GIPAGPL;to file start
          CALL hexSAVE;save changes
;---------
NOsave    CALL RRESB
          POP IX
          XOR A
          RET
;---------------------------------------
hexSAVE LD DE,(DADE),HL,(DAHL)
.6      SRL E:RR H;/16384
        LD A,H:ADD A,TVBPG+1:LD (Tsave+1),A

        LD A,TVBPG,(TSAVE+1),A
TSAVE   LD A,0:CALL MNGCVPLx
        LD HL,TSAVE+1:INC (HL)
        LD HL,#C000,B,32:CALL SAVE512:CP #0F:RET Z
        LD A,(TSAVE+1)
Tsave   CP 0:RET NC
        CP TVEPG:RET NC
        JP TSAVE

;---------------------------------------
SEARCH_ CALL CTRL:LD A,0:RET Z
        CALL SHIFT:RET NZ
        CALL ALT:RET NZ

        LD A,1:CALL KBSCN
        CP "f":JR Z,SEARCH
        CP "s":JP Z,SAVE_FILE
        RET
;-------
SEARCH  PUSH IX
        LD IX,SRHWND:CALL PRWOW

        LD C,0:CALL STRBULL:JR Z,SRHZERO
        LD C,E
SRHZERO EXX:LD HL,STRBUFFL
        EXX:LD HL,STRBUFF,DE,#0101,B,SRHSTRLN,A,#FD:CALL ISTR
        LD HL,#01FF,A,#FE:CALL ISTR
SRHMAIN EI:HALT
        CALL ENKE:JR NZ,GO_SRH
        CALL ESC:JR NZ,SRHEXIT

        XOR A:CALL ISTR
        LD A,2:CALL ISTR
        LD A,3:CALL ISTR
        JR SRHMAIN

SRHEXIT CALL RRESB
        POP IX
        XOR A
        RET
;-------
STRBULL LD DE,STRBUFFL
        LD HL,STRBUFF+STRBUFFL-1
STRSTRS LD A,(HL):CP " ":RET NZ
        DEC HL,DE:LD A,D:OR E:JR NZ,STRSTRS
STRSTR  XOR A
        RET
;-------
GO_SRH   CALL RRESB:POP IX
         CALL STRBULL:RET Z;if Z:A=0
         INC HL:LD BC,HL
BINSRH   LD HL,(CURU),(CURD),HL
         LD A,(CUPU),(CUPG),A:CALL MNGCVPLx
         EX DE,HL
SRHO     LD HL,STRBUFF
SRHYO    LD A,D:CP #C0:CALL C,SRHNXPG:RET C
         LD A,(DE):CP (HL):INC DE:JR NZ,SRHYO:INC HL
         LD A,B:CP H:JR NZ,SRHYO2
         LD A,C:CP L:JR Z,SRHFOUND
SRHYO2   LD A,D:CP #C0:CALL C,SRHNXPG:RET C
         LD A,(DE):CP (HL):JR NZ,SRHO:INC HL,DE
         LD A,B:CP H:JR NZ,SRHYO2
         LD A,C:CP L:JR NZ,SRHYO2

SRHFOUND EX DE,HL
         LD A,L:AND %11110000:LD L,A
         LD (CURU),HL,A,(CUPG),(CUPU),A
         XOR A:LD A,1
         RET

SRHNXPG  LD A,(CUPG):INC A:CP TVEPG+1:JR NC,SNP
         LD (CUPG),A:CALL MNGCVPLx
         LD DE,#C000
         XOR A
         RET
SNP      SCF
         RET
;---------------------------------------
BYF10   PUSH AF
;LD HL,0,(DADE),HL,(DAHL),HL
        LD HL,DIRDIR:CALL FENTRY;if root dir - need to reset CRRR(4) (but how?)
        CALL GFILE
        CALL REK
        LD IX,TVWND:CALL PRWOW
        POP AF
        JP VBIN
;---------------------------------------
TVHEAD  LD HL,LOBU
        PUSH HL
        LD (HL),#8:INC HL
        LD (HL),#1:INC HL:LD DE,HL
        LD A," ",B,(IX+4):CALL NOPING+1
        LD (HL),#00

        LD HL,(BUX),B,(IX+4)
TVNML   LD A,(HL):CP #20:JR C,TVHBB
        LD (DE),A:INC HL,DE
        DJNZ TVNML
TVHBB   POP HL
        LD DE,#0000:JP TXTPR
;-------
TVPGUP  LD HL,(CURU)
        LD B,(IX+5):DEC B
PUP     PUSH BC:LD BC,CUPU:CALL SERUP
        POP BC:JR C,TVup
        DJNZ PUP
        LD (CURU),HL
        JP PGPR

TVPGDN  CALL DWNF:RET Z

        LD (CURU),HL
        LD A,(CUPG),(CUPU),A
        JP PGPR
;-------
TVup    LD HL,#C000,(CURU),HL:JP PGPR
TVUP    LD HL,(CURU),BC,CUPU
        CALL SERUP:JR C,TVup
        LD (CURU),HL

        LD HL,EDFL,A,(HL)
        OR A:JR Z,$+5:DEC (HL):JR NZ,M3

        LD HL,(CURD),BC,CUPG
        CALL SERUP
        LD (CURD),HL

M3      LD B,(IX+5):DEC B
        LD C,80
        LD DE,#0100
        LD A,%00000000:CALL SCRLWOW

        LD DE,#0100
        LD HL,(CURU),(THL),HL:JP LNPRU
;-------
DWNF    LD A,(CUPG):CALL MNGCVPLx
        LD HL,(CURD),A,(HL):OR A
        RET

TVDN    CALL DWNF:RET Z

        LD B,(IX+5):DEC B
        LD C,80
        LD DE,#0100
        LD A,%00000001:CALL SCRLWOW

        LD E,0
        LD D,(IX+5):DEC D
        LD HL,(CURD),(THL),HL:CALL LNPR
        LD HL,(THL),(CURD),HL

        LD A,(CUPG)
        PUSH AF
        LD A,(CUPU),(CUPG),A:CALL MNGCVPLx
        LD HL,(CURU):CALL SERDN
        LD (CURU),HL
        LD A,(CUPG),(CUPU),A
        POP AF
        LD (CUPG),A
        RET
;-------
PGPR    XOR A:LD (EDFL),A

        LD A,(CUPU),(CUPG),A
        LD HL,(CURU),(THL),HL

        LD B,(IX+5):DEC B
        LD DE,#0100
MNC     PUSH DE,BC
        CALL LNPR

        LD A,(CUPG):CALL MNGCVPLx
        LD HL,(THL),A,(HL)
        OR A:CALL Z,ZERL

        POP BC,DE:INC D:DJNZ MNC
        LD HL,(THL),(CURD),HL
        RET

ZERL    LD HL,EDFL:INC (HL):RET
;-------
LNPRU   LD A,(CUPG)
        PUSH AF
        LD A,(CUPU),(CUPG),A:CALL LNPR
        POP AF
        LD (CUPG),A
        RET

LNPR    LD A,(CUPG)
        CALL MNGCVPLx

        EXX
        LD HL,(THL)
        LD DE,LOBU:CALL LIGEN
        LD (THL),HL:CALL LIFIL
        EXX
        LD HL,LOBU,B,0,C,(IX+4):JP PRSRWx

LIGEN   LD BC,#0D0A
        LD A,H:OR A:CALL Z,A440
        LD A,(HL):OR A:RET Z
        CP B:JR NZ,$+3:INC HL
        LD A,H:OR A:CALL Z,A440
        LD A,(HL)
        CP C:JR NZ,$+3:INC HL

LILI    LD A,H:OR A:CALL Z,A440
        LD A,D:CP LOBU[+4:RET NC
        LD A,(HL):OR A:RET Z
        CP B:RET Z
        CP C:RET Z:INC HL
        LD (DE),A:INC DE
        JP LILI

LIFIL   LD A,D:CP LOBU[+1:RET NC
        LD A,E:SUB (IX+4):RET NC
        EX DE,HL
        NEG:LD B,A:JP NOPING

CRPR    RET
;-------
SERDN   LD BC,#0D0A
        LD A,H:OR A:CALL Z,A440
        LD A,(HL):OR A:RET Z
        CP B:JR NZ,$+3:INC HL
        LD A,H:OR A:CALL Z,A440
        LD A,(HL)
        CP C:JR NZ,$+3:INC HL

LILI2   LD A,H:OR A:CALL Z,A440
        LD A,(HL):OR A:RET Z
        CP B:RET Z
        CP C:RET Z:INC HL
        JP LILI2
;-------
SERUP   LD (A440U+1),BC,A,(BC)
        CALL MNGCVPLx
        
        LD BC,#0D0A
SERup   DEC HL
        LD A,H:CP #C0
        CALL C,A440U:RET C

        LD A,(HL)
        CP B:RET Z
        CP C:JR NZ,SERup
        DEC HL
        LD A,H:CP #C0
        CALL C,A440U:RET C

        LD A,(HL):CP B:RET Z
        INC HL
        LD A,H:OR A:CALL Z,A440D
        RET
;-------
A440D   LD HL,(A440U+1):JR $+5
A440    LD HL,CUPG:INC (HL)
        LD A,(HL):CALL MNGCVPLx
        LD HL,#C000
        RET

A440U   LD HL,0
        LD A,(HL):SUB 1:RET C;TVBPG=0
        LD (HL),A:CALL MNGCVPLx
        LD HL,#FFFF
        XOR A
        RET
;-------
SER13D  LD C,13
SER     LD A,(HL)
        OR A:RET Z:INC HL
        CP C:RET Z
        JP SER
;---------------------------------------
CHEBUREK LD A,TVBPG
         LD (CUPG),A
         LD (CUPU),A
         LD HL,#C000,(CURU),HL

         XOR A:LD (EDITcurX),A
         LD (IX+12),EDITcurYstart
         LD A,(IX+5):DEC A:LD (IX+13),A
         RET

REK      LD A,TVBPG
         LD (CUPG),A
         LD (CUPU),A
         LD HL,#C000,(CURU),HL

         CALL TLOAD:LD A,TVBPG,(CUPG),A
         RET
;-------
TLOAD    LD A,(CUPG):CP TVEPG+1:RET NC
         CALL MNGCVPLx
         LD HL,#C000,B,32:CALL LOAD512
         CP #0F:RET Z
         LD HL,CUPG:INC (HL)
         JR TLOAD

;---------------------------------------
;---------------------------------------
EDITcurYstart   EQU 1
EDITcurXmax     EQU 16-1

EDITcurTXTstart EQU 18
EDITcurTXTwidth EQU 1
EDITcurTXTcolor EQU EDITcurCOLOR+128
EDITcurHEXstart EQU 36
EDITcurHEXwidth EQU 2
EDITcurHEXtab   EQU 1
EDITcurHEXcolor EQU EDITcurCOLOR+128+2

EDITbinMASK     EQU %0000 0111
EDITcurCOLOR    EQU %0101 1000
;---------------------------------------
EDIT_BIN EI:HALT
         CALL CURSOR,XCURSOR

         CALL SEARCH_:JR NZ,EDIT_BIN:DEC A:JR Z,cEREFR
         CALL TABK:JR NZ,toRERE

         LD A,1:CALL KBSCN,NZ,HEXADD:JR NZ,EREFR
         CALL LFFF,NZ,editCRBLF
         CALL RGGG,NZ,editCRBRG
         CALL UPPP,NZ,editCRBUP:JR NZ,EREFR
         CALL DWWW,NZ,editCRBDN:JR NZ,EREFR
         CALL PGU,NZ,CRBPGUP:JR NZ,EREFR
         CALL PGD,NZ,CRBPGDN:JR NZ,EREFR

         CALL F1,NZ,HELP
         CALL ESC:JR Z,EDIT_BIN
         CALL CURSER
         JP REEX
toRERE   CALL CURSER:JP RERE
;--------
cEREFR   CALL CURSER:LD (IX+12),EDITcurYstart
         CALL CURSOR
EREFR    CALL PGPRB:JR EDIT_BIN
;--------
editCRBDN LD A,(IX+12):CP (IX+13):JP NC,CRBDN:CALL CURSER:INC (IX+12):JR editCRBxx
editCRBUP LD A,(IX+12):CP EDITcurYstart:JP Z,CRBUP:CALL CURSER:DEC (IX+12)
editCRBxx CALL CURSOR,XCURSOR
          XOR A
          RET

editCRBLF LD HL,EDITcurX,A,(HL):OR A:RET Z:DEC (HL):RET
editCRBRG LD HL,EDITcurX,A,(HL):CP EDITcurXmax:RET NC:INC (HL):RET
;--------
XCURSOR LD A,(EDITcurX):ADD A,EDITcurTXTstart+EDITcurTXTwidth:LD D,(IX+12),E,A:CALL GADRWx
        LD B,EDITcurTXTwidth,A,EDITcurTXTcolor:CALL PRIATx

BLINK   LD A,0:INC A:LD (BLINK+1),A:AND %1000:RET Z
        LD A,(EDITcurX):OR A:JR Z,HEXstart
        LD B,A:XOR A:ADD A,EDITcurHEXwidth+EDITcurHEXtab:DJNZ $-2
          
HEXstart ADD A,EDITcurHEXstart+EDITcurHEXwidth:LD D,(IX+12),E,A:CALL GADRWx
         LD B,EDITcurHEXwidth,A,EDITcurHEXcolor:JP PRIATx
;--------
notHEX   XOR A:RET

HEXADD   LD HL,#2020,(EDIThexBU),HL
         CP "0":JR C,notHEX
         CP "9"+1:JR C,HEXadd
         CP "a":JR C,notHEX
         CP "f"+1:JR NC,notHEX
         RES 5,A
HEXadd   LD (EDIThexBU),A

         LD A,(EDITcurX):OR A:JR Z,HEXstarT
         LD B,A:XOR A:ADD A,EDITcurHEXwidth+EDITcurHEXtab:DJNZ $-2
HEXstarT ADD A,EDITcurHEXstart
         LD HL,EDIThexBU,D,(IX+12),E,A,BC,EDITcurHEXwidth:CALL PRSRWx

HEXadd2  EI:HALT
         LD A,1:CALL KBSCN:JR NZ,HEXadd3
         CALL ESC:JR Z,HEXadd2
notHEX2  LD A,1:OR A
         RET

HEXadd3  CP "0":JR C,notHEX2
         CP "9"+1:JR C,HEXfin
         CP "a":JR C,notHEX2
         CP "f"+1:JR NC,notHEX2
         RES 5,A
HEXfin   LD (EDIThexBU+1),A
         SUB "0":CP 10:JR C,$+4
         SUB "A"-"9"-1
         AND %00001111:LD C,A
         LD A,(EDIThexBU)
         SUB "0":CP 10:JR C,$+4
         SUB "A"-"9"-1
         AND %00001111
.4       RLA
         ADD A,C:LD C,A

         LD A,(CUPG):CALL MNGCVPLx
         LD A,(IX+12):DEC A:LD D,0,E,A
.4       SLA E:RL D
         LD HL,(CURU):ADD HL,DE
         LD DE,(EDITcurX),D,0:ADD HL,DE
         LD (HL),C
         JR notHEX2

;---------------------------------------
VBIN    CALL CHEBUREK
        CALL COLORING
        CALL PGPRB

MBI     EI:HALT

        CALL SEARCH_:JR NZ,MBI:DEC A:JR Z,BREFR
        CALL TABK:JP NZ,RERE

        CALL UPPP,NZ,CRBUP:JR NZ,BREFR
        CALL DWWW,NZ,CRBDN:JR NZ,BREFR
        CALL PGU,NZ,CRBPGUP:JR NZ,BREFR
        CALL PGD,NZ,CRBPGDN:JR NZ,BREFR

        CALL SPKE:JP NZ,REEX
        CALL ENKE:JP NZ,EDIT_BIN
        CALL F1,NZ,HELP
        CALL ESC:JR Z,MBI
        JP REEX

BREFR   CALL PGPRB
        JR MBI
;-------
PGPRB   LD HL,(CURU),(CURD),HL
        LD A,(CUPU),(CUPG),A     
        LD BC,(HEI-1)
        LD DE,#0100; Y+X
        LD A,B:DEC B:CP 36:JR NZ,BCD
        LD E,5
BCD     PUSH BC
        PUSH DE        
        PUSH DE:CALL ZBUB
        POP DE:LD HL,HEXLINE,BC,HEXLINEL:CALL PRSRWx
        POP DE:INC D
        POP BC:DJNZ BCD
        RET

ZBUB    LD HL,(CURD)
        LD A,(CUPG):CALL MNGCVPLx
        LD A,H:CP #C0:JR NC,BUB
        LD A,(CUPG):INC A:CP TVEPG+1:JP NC,BuB
        LD (CUPG),A:CALL MNGCVPLx
        LD HL,#C000

BUB     LD A,(DADE+1):OR A:JR NZ,BUB_OK
        LD B,A
        LD A,(CUPG):SRL A:RR B:SRL A:RR B:LD C,A
        LD A,(DADE):CP C:JR Z,$+4,NC,BUB_OK
        LD A,H:AND %00111111:OR B
        LD BC,(DAHL):CP B:JR C,BUB_OK,Z,$+4,NC,BUB_NO
        LD A,L:CP C:JR C,BUB_OK
BUB_NO  PUSH HL
        LD HL,NOPETXT,DE,BTEXT,BC,16:LDIR
        LD HL,NOPETXT,DE,BHEX,BC,16*3:LDIR
        POP HL
        LD C,16:ADD HL,BC
        EX DE,HL
        JR BUB_ALT
BUB_OK  PUSH HL:LD DE,BTEXT,BC,16:LDIR
        POP DE

        LD B,16,HL,BHEX
B_B     PUSH BC
        LD A,(DE):INC DE
        INC HL
        LD C,A
        AND %00001111:CP 10:JR C,$+4:ADD A,7,A,#30
        LD (HL),A:DEC HL
        LD (HL),C
        XOR A
        RLD:CP 10:JR C,$+4:ADD A,7,A,#30
        LD (HL),A
        LD BC,BHEXSTEP:ADD HL,BC
        POP BC
        DJNZ B_B

BUB_ALT PUSH DE
        LD HL,BADDRESS+2,A,(CUPG):SRL A,A:CALL NORK8BIT
        LD A,(CURD+1):SUB #C0:JR NC,$+4:ADD A,#C0:LD C,A
        LD A,(CUPG):AND %11:RRCA:RRCA:ADD A,C:CALL NORK8BIT
        LD A,(CURD):CALL NORK8BIT
        POP HL
        LD (CURD),HL
BuB     RET
;--------
CRBUP    LD HL,(CURU)
         LD BC,16:OR A:SBC HL,BC
         LD A,H:CP #C0:JR NC,CARBON
         LD A,(CUPU):SUB 1;TVBPG=0
         JR C,CRUPDNER
         LD (CUPU),A
         LD HL,0-16
         JR CARBON

CRBDN    LD HL,(CURU)
         LD BC,16:ADD HL,BC
         LD A,H:CP #C0:JR NC,CARBON
         LD A,(CUPU):INC A
         CP TVEPG+1:JR NC,CRUPDNER
         LD (CUPU),A
         LD HL,#C000
CARBON   LD (CURU),HL
         XOR A:INC A
         RET

CRUPDNER XOR A
         RET
;--------
CRBCALC  LD HL,(HEI),H,0:DEC L
.4       ADD HL,HL
         LD BC,HL
         LD HL,(CURU)
         RET

CRBPGUP  CALL CRBCALC
         OR A:SBC HL,BC
         LD A,H:CP #C0:JR NC,CARBON
         LD A,(CUPU):OR A:JR NZ,CRBPGUPC
         LD HL,#C000
         JR CARBON
CRBPGUPC DEC A:LD (CUPU),A
         LD BC,#4000:ADD HL,BC
         JR CARBON
;--------
CRBPGDN  CALL CRBCALC
         ADD HL,BC:JP NC,CARBON
         LD A,(CUPU):INC A
         CP TVEPG+1:JR NC,CRUPDNER
         LD (CUPU),A
         LD BC,0-#4000:ADD HL,BC
         JP CARBON
;---------------------------------------
COLORING LD A,(HEI):CP 36:RET C
         LD BC,5,DE,#0100; Y+X
CLR      PUSH BC:LD HL,NOPETXT:CALL PRSRWx:INC D
         POP BC:LD A,D:CP 36:JR C,CLR
         LD DE,#01*256+90-5
CLR2     PUSH BC:LD HL,NOPETXT:CALL PRSRWx:INC D
         POP BC:LD A,D:CP 36:JR C,CLR2
         RET

;---------------------------------------
ANALYZE  LD A,TVBPG:CALL MNGCVPLx
         LD HL,(DADE)
         LD A,L:OR H
         LD BC,(DAHL):JR Z,LYZE
         LD BC,#0FFF
LYZE     LD A,C:OR B:RET Z
         LD A,B:OR A:JR Z,LyZ
.2       SRL B:RR C
LyZ      LD HL,#C000
LYZ      LD A,(HL):INC HL
         CP #0A:JR Z,NXTLYZ
         CP #0D:JR Z,NXTLYZ
         CP #20:JR C,LYZFAIL
NXTLYZ   DEC BC:LD A,C:OR B:JR NZ,LYZ
         XOR A:INC A
         RET
LYZFAIL  XOR A
         RET
;---------------------------------------
NOPING   XOR A:LD (HL),A:INC HL:DJNZ $-2
         RET
;---------------------------------------
NORK8BIT ;i:HL - Address
;            A - value

         INC HL:LD C,A:AND %00001111:CP 10:JR C,$+4:ADD A,7,A,"0"
         LD (HL),A:DEC HL:LD (HL),C
         XOR A:RLD:CP 10:JR C,$+4:ADD A,7,A,"0":LD (HL),A:INC HL,HL
         RET
;---------------------------------------
INIT    PUSH AF
        LD A,#FF:CALL MNGC_PL
        LD HL,#C000,DE,#C800,BC,#800:LDIR
        LD HL,FONT,DE,#C000,BC,#800:LDIR;2KB

        LD A,#FE:CALL MNGC_PL
        POP AF
        RET

DEINIT  LD A,#FF:CALL MNGC_PL:LD HL,#C800,DE,#C000,BC,#800:LDIR
        LD A,#FE:CALL MNGC_PL
        RET
;---------------------------------------
INT_PL  EXA:LD A,86:JP WLD

MNGC_PL EXA:LD A,0:JP WLD
PRWOW   LD A,1:JP WLD
RRESB   LD A,2:JP WLD
PRSRWx  JP 0
PRIATx  JP 0
GADRWx  JP 0
CURSOR  LD A,6:JP WLD
CURSER  LD A,7:JP WLD
YN      EXA:LD A,8:JP WLD
ISTR    EXA:LD A,9:JP WLD
;NORK    EXA:LD A,10:JP WLD
TXTPR   LD A,11:JP WLD
SCRLWOW EXA:LD A,84:JP WLD
;-------
SPKE    LD A,16:JP WLD
UPPP    LD A,17:JP WLD
DWWW    LD A,18:JP WLD
LFFF    LD A,19:JP WLD
RGGG    LD A,20:JP WLD
TABK    LD A,21:JP WLD
ENKE    LD A,22:JP WLD
ESC     LD A,23:JP WLD
BSPC    LD A,24:JP WLD
PGU     LD A,25:JP WLD
PGD     LD A,26:JP WLD
HOME    LD A,27:JP WLD
END     LD A,28:JP WLD
F1      LD A,29:JP WLD
KBSCN   EXA:LD A,42:JP WLD
ALT     LD A,39:JP WLD
SHIFT   LD A,40:JP WLD
CTRL    LD A,41:JP WLD
USPO    LD A,46:JP WLD
NUSP    LD A,47:JP WLD
;-------
LOAD512 LD A,48:JP WLD
SAVE512 LD A,49:JP WLD
GIPAGPL LD A,50:JP WLD;reset to file start
STREAM  LD A,57:JP WLD
FENTRY  LD A,59:JP WLD;entryopen
GFILE   LD A,62:JP WLD;fileopen
MKFILE  LD A,72:JP WLD
;-------
MNGCVPLx JP 0
GVmod    EXA:LD A,66:JP WLD
;---------------------------------------
DAHL      DW 0
DADE      DW 0
TYPE      NOP;  byEXT,byF10,byGREENmenu
BUX       DS 2; File name

;-------TXTvw:
CUPU      NOP
CUPG      NOP

CURU      DW 0
CURD      DW 0

EDFL      NOP
;-------EDIT:
EDITcurX  DB 0
EDIThexBU DS 3
;-------
THL       DW 0

DIRDIR    DB #10,".",0
;---------------------------------------
TVWND     DB 64+16+3,EDITbinMASK
          DB 0,0;      X,Y
          DB 0,0;      W,H (MAX)
          DB TVWNDcolor;color
          DB 0
          DW #0000
          DB 0,0;      LINES
          DB 0,0;      curY,curMAX
          DB EDITcurCOLOR,TVWNDcolor
;---------
YNWND   DB 7+128,0
        DB 255,255;  X,Y
        DB 20+2,3+2; W,H
        DB %01111111;PAPER+INK
        DB 0
        DW #0; BUFFER
        DB 2,0;LINES

        DW 0
        DW 0
        DW YNM
YNM     DB #E,"Save changes?",0
;---------
SVWND   DB 7+128,0
        DB 255,255;  X,Y
        DB 20+2,1+2; W,H
        DB %01111111;PAPER+INK
        DB 0
        DW #0; BUFFER
        DB 0,0;LINES

        DW 0
        DW 0
        DW SAVINGM
SAVINGM DB #E,"Saving...",0
;---------
F1WND  DB 7+128,0
       DB 255,255;X,Y
       DB 64,13;  W,H
       DB %01111111
       DB 0
       DW #0
       DB 0,0

       DW F1T
       DW F1B
       DW F1A
F1T    DB #9,#E,"TXT&HEX Viewer HELP Page",0
F1B    DB #9,#E,"PRESS any key to CLOSE this Window",0
F1A    DB "Controls:",#D
       DB 1,"ESC - Exit (выход)",#D
       DB 1,"TAB - Switch between TXT/HEX viewers (переключение вьюверов)",#D
       DB 1,"ENTER - HEX editor mode (режим HEX редактора)",#D
       DB #D
       DB "HEX mode only:",#D
       DB 1,"ctrl+S - Save changes (сохранить изменения)",#D
;DB 1,"ctrl+alt+S - Save As (сохранить как)",#D
       DB 1,"ctrl+F - Find Text (поиск текста)",#D
;DB 1,"ctrl+G - Find Next (искать дальше)",#D
;DB 1,"ctrl+HOME - GO to File Start (перейти в начало файла)",#D
;DB 1,"ctrl+END - GO to File End (перейти в конец файла)",#D
       DB #D
       DB "Other Controls:",#D
       DB 1,"pgUP,pgDN,arrowUP,arrowDOWN",#D
       NOP
;---------
SRHWND DB 7+128,0
       DB 255,255; X,Y
       DB SRHSTRLN+2,1+2; W,H
       DB %01001111;color
       DB 0
       DW #0000
       DB 0,0; LINES

       DW SRHT; Head Text
       DW 0; Bottom
       DW 0; Body

SRHT DB #9,#E,"SEARCH:",0

STRBUFF   DS SRHSTRLN," "
STRBUFFL  EQU $-STRBUFF
;---------
HEXLINE   DB #BA," #"
BADDRESS  DB "00000000 ",#B3
BTEXT     DB "                ",#B3
BHEX      EQU $+1
BHEXSTEP  EQU 3
          DB " 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 ",#BA
HEXLINEL  EQU $-HEXLINE
;---------------------------------------
NOPETXT   DS 90," "
;---------------------------------------
FONT      INCB "r0bat_cp866.fnt"
ENDPL