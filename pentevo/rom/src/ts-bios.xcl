// xcl-file for assembler-only projects
-Fraw-binary
-cz80
-Z(CODE)CODE=0000-3FFF
-o ts-bios.bin
-l ts-bios.map
-xmisn
